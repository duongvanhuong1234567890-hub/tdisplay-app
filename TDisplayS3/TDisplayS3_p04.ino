static inline void xqAdd(XqMv *o, int &n, int f, int t) { o[n].f = f; o[n].t = t; o[n].sc = 0; n++; }
static int xqGen(XqMv *o, bool caps) {
 int n = 0, s = xqSide;
 for (int sq = 0; sq < 90; sq++) {
 int p = xqB[sq];
 if (!p || (p > 0) != (s > 0)) continue;
 int t = chAbs(p), r = sq / 9, c = sq % 9;
 if (t == XQ_R || t == XQ_C) {
 for (int i = 0; i < 4; i++) {
 int rr = r + XQ_O[i][0], cc = c + XQ_O[i][1];
 bool screen = false;
 while (rr >= 0 && rr < 10 && cc >= 0 && cc < 9) {
 int q = xqB[rr * 9 + cc];
 if (t == XQ_R) {
 if (q) { if ((q > 0) != (s > 0)) xqAdd(o, n, sq, rr * 9 + cc); break; }
 if (!caps) xqAdd(o, n, sq, rr * 9 + cc);
 } else {
 if (!screen) { if (q) screen = true; else if (!caps) xqAdd(o, n, sq, rr * 9 + cc); }
 else if (q) { if ((q > 0) != (s > 0)) xqAdd(o, n, sq, rr * 9 + cc); break; }
 }
 rr += XQ_O[i][0]; cc += XQ_O[i][1];
 }
 }
 } else if (t == XQ_H) {
 for (int i = 0; i < 8; i++) {
 int dr = XQ_H8[i][0], dc = XQ_H8[i][1], rr = r + dr, cc = c + dc;
 if (rr < 0 || rr > 9 || cc < 0 || cc > 8) continue;
 int lr = r + (chAbs(dr) == 2 ? dr / 2 : 0), lc = c + (chAbs(dc) == 2 ? dc / 2 : 0);
 if (xqB[lr * 9 + lc]) continue;
 int q = xqB[rr * 9 + cc];
 if (q && (q > 0) == (s > 0)) continue;
 if (caps && !q) continue;
 xqAdd(o, n, sq, rr * 9 + cc);
 }
 } else if (t == XQ_S) {
 int dir = s > 0 ? -1 : 1, rr = r + dir;
 bool crossed = s > 0 ? r <= 4 : r >= 5;
 if (rr >= 0 && rr < 10) { int q = xqB[rr * 9 + c]; if (!(q && (q > 0) == (s > 0)) && !(caps && !q)) xqAdd(o, n, sq, rr * 9 + c); }
 if (crossed) for (int dc = -1; dc <= 1; dc += 2) {
 int cc = c + dc; if (cc < 0 || cc > 8) continue;
 int q = xqB[r * 9 + cc];
 if (q && (q > 0) == (s > 0)) continue;
 if (caps && !q) continue;
 xqAdd(o, n, sq, r * 9 + cc);
 }
 } else if (t == XQ_G || t == XQ_A) {
 for (int i = 0; i < 4; i++) {
 int rr = r + (t == XQ_G ? XQ_O[i][0] : XQ_D[i][0]), cc = c + (t == XQ_G ? XQ_O[i][1] : XQ_D[i][1]);
 if (!xqPal(rr, cc, s)) continue;
 int q = xqB[rr * 9 + cc];
 if (q && (q > 0) == (s > 0)) continue;
 if (caps && !q) continue;
 xqAdd(o, n, sq, rr * 9 + cc);
 }
 } else {
 for (int i = 0; i < 4; i++) {
 int rr = r + XQ_D[i][0] * 2, cc = c + XQ_D[i][1] * 2;
 if (rr < 0 || rr > 9 || cc < 0 || cc > 8) continue;
 if (s > 0 ? rr < 5 : rr > 4) continue;
 if (xqB[(r + XQ_D[i][0]) * 9 + c + XQ_D[i][1]]) continue;
 int q = xqB[rr * 9 + cc];
 if (q && (q > 0) == (s > 0)) continue;
 if (caps && !q) continue;
 xqAdd(o, n, sq, rr * 9 + cc);
 }
 }
 }
 return n;
}
static void xqMake(const XqMv &m, XqUn &u) {
 u.f = m.f; u.t = m.t; u.cap = xqB[m.t]; u.half = xqHalf;
 xqHalf = u.cap ? 0 : xqHalf + 1;
 xqB[m.t] = xqB[m.f]; xqB[m.f] = 0; xqSide = -xqSide;
}
static void xqUnmake(const XqUn &u) { xqSide = -xqSide; xqB[u.f] = xqB[u.t]; xqB[u.t] = u.cap; xqHalf = u.half; }
static bool xqInCheck(int s) { int k = xqKingSq(s); return k >= 0 && xqAtt(k, -s); }
static bool xqSafeAfter(int s) { int k = xqKingSq(s); return k >= 0 && !xqAtt(k, -s); }
static int xqLegal(XqMv *o) {
 XqMv tmp[128]; int n = xqGen(tmp, false), k = 0, s = xqSide;
 for (int i = 0; i < n; i++) { XqUn u; xqMake(tmp[i], u); bool ok = xqSafeAfter(s); xqUnmake(u); if (ok) o[k++] = tmp[i]; }
 return k;
}
static int xqEval() {
 int sc = 0;
 for (int sq = 0; sq < 90; sq++) {
 int p = xqB[sq]; if (!p) continue;
 int t = chAbs(p), r = sq / 9, c = sq % 9;
 int adv = p > 0 ? 9 - r : r;
 int cx = c < 4 ? c : 8 - c;
 int v = XQ_VAL[t];
 switch (t) {
 case XQ_S: if (adv >= 5) v += 60 + (adv - 5) * 12 + (cx >= 2 ? 0 : 15); break;
 case XQ_H: v += cx * 6 + (adv >= 3 ? 10 : 0) + (adv >= 5 ? 15 : 0); break;
 case XQ_R: v += (adv >= 4 ? 15 : 0) + (cx == 4 ? 6 : 0); break;
 case XQ_C: v += (cx == 4 ? 12 : 0) + (adv >= 2 ? 8 : 0); break;
 case XQ_A: case XQ_E: v += 4; break;
 default: break;
 }
 sc += p > 0 ? v : -v;
 }
 return xqSide > 0 ? sc : -sc;
}
static unsigned long xqDead = 0; static bool xqAbort = false; static uint32_t xqNodes = 0;
static inline bool xqTick() {
 if ((++xqNodes & 127) == 0) {
 esp_task_wdt_reset();
 if ((long)(millis() - xqDead) >= 0 || (xqNodes > 5000 && mgUserWantsOut())) xqAbort = true;
 }
 return xqAbort;
}
static void xqScore(XqMv *m, int n) {
 for (int i = 0; i < n; i++) {
 int cap = xqB[m[i].t];
 m[i].sc = cap ? XQ_VAL[chAbs(cap)] * 10 - XQ_VAL[chAbs(xqB[m[i].f])] / 10 + 100 : 0;
 }
}
static inline void xqPick(XqMv *m, int n, int i) {
 int b = i; for (int j = i + 1; j < n; j++) if (m[j].sc > m[b].sc) b = j;
 if (b != i) { XqMv t = m[i]; m[i] = m[b]; m[b] = t; }
}
static int xqQ(int alpha, int beta, int qd) {
 if (xqTick()) return 0;
 int stand = xqEval();
 if (stand >= beta) return stand;
 if (stand > alpha) alpha = stand;
 if (qd <= 0) return alpha;
 XqMv mv[64]; int n = xqGen(mv, true); if (n > 64) n = 64;
 xqScore(mv, n);
 int s = xqSide;
 for (int i = 0; i < n; i++) {
 xqPick(mv, n, i);
 XqUn u; xqMake(mv[i], u);
 if (!xqSafeAfter(s)) { xqUnmake(u); continue; }
 int v = -xqQ(-beta, -alpha, qd - 1);
 xqUnmake(u);
 if (xqAbort) return 0;
 if (v >= beta) return v;
 if (v > alpha) alpha = v;
 }
 return alpha;
}
static int xqNeg(int depth, int alpha, int beta, int ply) {
 if (xqTick()) return 0;
 if (xqHalf >= 120) return 0;
 int s = xqSide;
 bool inChk = xqInCheck(s);
 if (depth <= 0 && !inChk) return xqQ(alpha, beta, 4);
 if (depth <= -2) return xqEval();
 XqMv mv[128]; int n = xqGen(mv, false);
 xqScore(mv, n);
 int legal = 0;
 for (int i = 0; i < n; i++) {
 xqPick(mv, n, i);
 XqUn u; xqMake(mv[i], u);
 if (!xqSafeAfter(s)) { xqUnmake(u); continue; }
 legal++;
 int v = -xqNeg(depth - 1, -beta, -alpha, ply + 1);
 xqUnmake(u);
 if (xqAbort) return 0;
 if (v >= beta) return v;
 if (v > alpha) alpha = v;
 }
 if (!legal) return -30000 + ply;
 return alpha;
}
static bool xqBest(int level, XqMv &best) {
 XqMv mv[128]; int n = xqLegal(mv);
 if (!n) return false;
 if (n == 1) { best = mv[0]; return true; }
 int maxD = level == 0 ? 1 : (level == 1 ? 3 : 5);
 unsigned long ms = level == 0 ? 600 : (level == 1 ? 2500 : 5500);
 xqAbort = false; xqNodes = 0; xqDead = millis() + ms;
 xqScore(mv, n);
 for (int i = 0; i < n; i++) xqPick(mv, n, i);
 int sc[128]; for (int i = 0; i < n; i++) sc[i] = 0;
 int done = 0;
 int margin = level == 0 ? 160 : (level == 1 ? 12 : 0);
 for (int d = 1; d <= maxD; d++) {
 int bi = -1, bv = -32000;
 int tmp[128];
 for (int k = 0; k < n; k++) {
 int a = (bv == -32000) ? -32000 : bv - margin - 1;
 XqUn u; xqMake(mv[k], u);
 int v = (level == 0) ? -xqQ(-32000, -a, 0) : -xqNeg(d - 1, -32000, -a, 1);
 xqUnmake(u);
 if (xqAbort) break;
 tmp[k] = v;
 if (v > bv) { bv = v; bi = k; }
 }
 if (xqAbort) break;
 for (int k = 0; k < n; k++) sc[k] = tmp[k];
 done = d;
 XqMv t = mv[bi]; int ts = sc[bi];
 for (int k = bi; k > 0; k--) { mv[k] = mv[k - 1]; sc[k] = sc[k - 1]; }
 mv[0] = t; sc[0] = ts;
 if (bv > 29000) break;
 }
 if (!done) { best = mv[0]; return true; }
 int top = sc[0]; for (int k = 1; k < n; k++) if (sc[k] > top) top = sc[k];
 int cand[128], nc = 0;
 for (int k = 0; k < n; k++) if (sc[k] >= top - margin) cand[nc++] = k;
 best = mv[cand[nc > 1 ? (int)(random(nc)) : 0]];
 return true;
}
void mgExit();
#define CX_BTN_MODE 1
#define CX_BTN_UNDO 2
#define CX_BTN_NEW 3
#define CX_BTN_EXIT 4
static String cxModeText(int m) {
 switch (m) {
 case 0: return tr("CPU: Easy", "Máy: Dễ");
 case 1: return tr("CPU: Med", "Máy: TB");
 case 2: return tr("CPU: Hard", "Máy: Khó");
 default: return tr("2 players", "2 người");
 }
}
static void cxBtn(int x, int y, int w, int h, const String &t, uint16_t fill) {
 fillRoundRectAA(x, y, w, h, 10, fill, MG_BG);
 mgTxtC(t, x + w / 2, y + h / 2, DATUM_MC, MG_TXT, fill);
}
static void cxPanel(int px, int pw, int mode) {
 int hw = (pw - 4) / 2;
 cxBtn(px, 68, pw, 30, cxModeText(mode), MGC(60, 90, 150));
 cxBtn(px, 101, hw, 31, tr("Undo", "Lùi"), MG_PANEL);
 cxBtn(px + hw + 4, 101, hw, 31, tr("New", "Mới"), MG_PANEL);
 cxBtn(px, 135, pw, 32, tr("Exit", "Thoát"), MGC(120, 50, 60));
}
static int cxHit(int x, int y, int px, int pw) {
 if (x < px - 4 || y < 64) return 0;
 if (y < 100) return CX_BTN_MODE;
 if (y < 133) return (x < px + (pw - 4) / 2 + 2) ? CX_BTN_UNDO : CX_BTN_NEW;
 return CX_BTN_EXIT;
}
static void cxStatus(int px, const String &title, const String &l2, uint16_t c2, const String &l3) {
 mgTxtC(title, px + 2, 3, DATUM_TL, MG_DIM, MG_BG);
 mgTxtC(l2, px + 2, 25, DATUM_TL, c2, MG_BG);
 mgTxtC(l3, px + 2, 46, DATUM_TL, MG_TXT, MG_BG);
}
#define CX_GOLD MGC(255, 230, 90)
#define CX_ALERT MGC(255, 90, 90)
const uint8_t XQS_A[] PROGMEM =
 "\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070\343\377\377\377\377\377"
 "\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000"
 "\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\200\160\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\000\070"
 "\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357"
 "\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000"
 "\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377"
 "\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\010\357\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\110\377\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\000\000\070\343\377\377"
 "\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000"
 "\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070\343\377\377\377"
 "\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020"
 "\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\200"
 "\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000"
 "\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357\377\377\377\377"
 "\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000"
 "\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377\377\377\377\377"
 "\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\010\357\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\110\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\000\000\070\343"
 "\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000"
 "\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070\343\377"
 "\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377"
 "\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020"
 "\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357\377\377"
 "\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000"
 "\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377\377\377"
 "\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\010"
 "\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\110\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\000\000"
 "\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010"
 "\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070"
 "\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377"
 "\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377"
 "\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357"
 "\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000"
 "\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377"
 "\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217"
 "\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160"
 "\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000"
 "\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160"
 "\110\010\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000"
 "\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377"
 "\377\377\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020"
 "\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000"
 "\000\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377"
 "\377\377\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\217\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\160\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000"
 "\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160"
 "\200\160\110\010\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000"
 "\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377"
 "\377\377\377\377\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000"
 "\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010"
 "\000\000\000\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363"
 "\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\217\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\160\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363"
 "\070\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010"
 "\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000"
 "\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377"
 "\377\377\377\377\377\377\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357"
 "\010\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110"
 "\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377"
 "\377\377\377\377\377\377\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000"
 "\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160\110\010\000\000\000\000\000\000\000\000\000\000\000\000\010\110\160\200\160"
 "\110\010\000\000\000\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000"
 "\070\363\377\377\377\377\377\377\377\377\377\377\377\363\070\000\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\217\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\217\000\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\160\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\160\200\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\200\160\377\377\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\377\160\110\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\110\010\357\377\377\377\377\377\377\377\377\377\377\377\377\377\377\377\357\010\000\217\377\377"
 "\377\377\377\377\377\377\377\377\377\377\377\377\377\217\000\000\020\343\377\377\377\377\377\377\377\377\377\377\377\377\377\343\020\000\000\000\070\363\377\377\377\377\377\377\377\377\377\377"
 "\377\363\070\000\000\000\000\000\070\343\377\377\377\377\377\377\377\377\377\343\070\000\000\000\000\000\000\000\020\217\357\377\377\377\377\377\357\217\020\000\000\000\000\000\000\000\000\000"
 "\000\010\110\160\200\160\110\010\000\000\000\000\000\000";
const uint8_t XQS_B[] PROGMEM =
 "\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360\360\220\020\004\011\013"
 "\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\007\001\000\001\007\016\005\100\340\360\000\000\000\360\360\100\011\017\017\000\000\000\000\000\000\017\012\100\360\360\000\000"
 "\360\220\005\011\015\017\010\017\017\017\017\007\017\017\005\220\360\000\360\360\020\016\000\015\017\013\017\017\017\017\010\017\007\016\020\360\360\360\260\004\007\000\015\017\013\016\016\011"
 "\017\010\017\007\007\004\260\360\360\200\011\004\006\017\017\016\017\017\015\017\015\017\014\005\011\200\360\360\200\013\005\017\017\017\017\017\017\017\017\017\017\017\010\013\200\360\360\200"
 "\011\004\006\017\017\016\017\017\015\017\015\017\014\005\011\200\360\360\260\004\007\000\015\017\013\016\016\011\017\010\017\007\007\004\260\360\360\360\020\016\000\015\017\013\017\017\017\017"
 "\010\017\007\016\020\360\360\000\360\220\005\011\015\017\011\017\017\017\017\007\017\017\005\220\360\000\000\360\360\100\011\017\017\000\000\000\000\000\000\017\012\100\360\360\000\000\000\360"
 "\340\100\005\017\007\001\000\001\007\016\005\100\340\360\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360"
 "\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000"
 "\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\007\001\000\001\007\016\005"
 "\100\340\360\000\000\000\360\360\100\012\017\006\000\000\000\000\000\000\011\011\100\360\360\000\000\360\220\005\016\017\017\012\015\015\015\015\015\015\017\005\220\360\000\360\360\020\016\000"
 "\000\011\003\017\017\017\017\017\017\017\017\020\360\360\360\260\004\007\007\017\017\003\017\010\017\010\017\006\017\012\004\260\360\360\200\011\001\002\011\006\001\017\011\017\011\017\007\017"
 "\004\011\200\360\360\200\013\000\000\016\017\005\017\017\017\017\017\017\017\002\013\200\360\360\200\011\001\000\015\010\003\017\017\017\017\017\016\017\004\011\200\360\360\260\004\007\000\010"
 "\017\014\017\010\017\010\017\005\017\012\004\260\360\360\360\020\016\017\016\011\002\017\010\017\010\017\005\017\017\020\360\360\000\360\220\005\017\017\017\017\017\007\015\004\015\004\017\005"
 "\220\360\000\000\360\360\100\011\017\017\017\017\005\000\000\000\011\011\100\360\360\000\000\000\360\340\100\005\016\007\002\000\001\007\016\005\100\340\360\000\000\000\000\000\360\360\220\020"
 "\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000"
 "\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360\360\220\020\004"
 "\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\007\001\000\001\007\016\005\100\340\360\000\000\000\360\360\100\011\016\003\004\002\000\000\001\015\011\011\100\360\360"
 "\000\000\360\220\005\017\017\015\014\017\011\013\017\017\010\011\005\220\360\000\360\360\020\016\003\017\013\017\017\017\017\017\017\017\007\016\020\360\360\360\260\004\010\003\017\014\017\015"
 "\017\016\010\017\017\017\014\004\260\360\360\200\011\011\017\012\017\015\017\017\017\013\015\016\017\002\011\200\360\360\200\013\007\017\010\017\017\017\017\017\017\017\017\010\000\013\200\360"
 "\360\200\011\002\017\017\017\017\012\010\017\013\017\017\010\001\011\200\360\360\260\004\007\000\010\013\017\014\010\016\010\017\016\000\007\004\260\360\360\360\020\016\000\007\017\017\017\015"
 "\017\017\015\000\000\016\020\360\360\000\360\220\005\017\017\017\002\017\016\017\017\015\000\011\005\220\360\000\000\360\360\100\012\017\000\000\001\000\000\000\000\011\011\100\360\360\000\000"
 "\000\360\340\100\005\016\007\001\000\001\007\016\005\100\340\360\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360\260\200\200\200"
 "\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000"
 "\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\007\001\000\001\007"
 "\016\005\100\340\360\000\000\000\360\360\100\012\015\000\000\000\000\017\012\000\011\011\100\360\360\000\000\360\220\005\017\016\000\000\000\000\017\013\000\000\011\005\220\360\000\360\360\020"
 "\016\017\016\000\000\000\000\017\013\000\000\000\016\020\360\360\360\260\004\007\017\016\000\000\000\000\017\013\000\000\000\007\004\260\360\360\200\011\001\017\017\006\006\006\007\017\016\006"
 "\006\006\002\011\200\360\360\200\013\000\017\017\017\017\017\017\017\017\017\017\017\002\013\200\360\360\200\011\001\017\017\010\010\010\011\017\017\010\010\010\003\011\200\360\360\260\004\007"
 "\017\016\000\000\000\000\017\013\000\000\000\007\004\260\360\360\360\020\016\017\016\000\000\000\000\017\013\000\000\000\016\020\360\360\000\360\220\005\017\016\000\000\000\000\017\013\000\000"
 "\011\005\220\360\000\000\360\360\100\014\017\000\000\000\000\017\013\000\011\011\100\360\360\000\000\000\360\340\100\005\016\007\001\000\005\011\016\005\100\340\360\000\000\000\000\000\360\360"
 "\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000"
 "\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360\360\220"
 "\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\007\006\001\001\007\016\005\100\340\360\000\000\000\360\360\100\017\017\016\014\017\005\005\015\016\017\014\100"
 "\360\360\000\000\360\220\005\013\013\017\017\017\005\010\017\016\016\017\005\220\360\000\360\360\020\017\012\012\012\013\017\015\016\017\012\012\012\017\020\360\360\360\260\004\015\017\017\017"
 "\017\017\017\017\017\017\017\017\017\004\260\360\360\200\011\001\000\000\000\003\013\007\006\013\013\003\000\001\011\200\360\360\200\013\000\000\000\014\017\017\017\015\017\017\017\000\000\013"
 "\200\360\360\200\011\001\000\015\017\017\017\016\017\013\015\017\015\002\011\200\360\360\260\004\011\017\015\002\006\017\003\017\017\017\017\017\015\004\260\360\360\360\020\017\017\017\014\017"
 "\017\015\016\017\014\016\015\017\020\360\360\000\360\220\005\017\017\017\017\017\017\010\011\017\017\017\005\220\360\000\000\360\360\100\011\011\000\006\017\000\000\000\004\017\011\100\360\360"
 "\000\000\000\360\340\100\005\016\011\006\000\001\007\016\005\100\340\360\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360\260\200"
 "\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000"
 "\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\010\006\000"
 "\001\007\016\005\100\340\360\000\000\000\360\360\100\011\017\007\017\017\016\007\002\000\017\017\100\360\360\000\000\360\220\005\017\017\017\017\017\017\017\017\017\017\017\005\220\360\000\360"
 "\360\020\016\000\017\016\004\004\016\017\006\012\017\016\016\020\360\360\360\260\004\007\000\017\017\017\017\017\017\000\000\017\016\007\004\260\360\360\200\011\001\000\002\003\003\003\003\016"
 "\017\010\011\007\001\011\200\360\360\200\013\000\015\017\017\017\017\017\017\017\017\017\010\001\013\200\360\360\200\011\007\017\016\013\017\017\015\017\004\017\017\017\003\011\200\360\360\260"
 "\004\015\017\002\000\017\017\017\017\002\017\015\003\007\004\260\360\360\360\020\017\017\002\006\017\015\015\015\001\017\014\000\016\020\360\360\000\360\220\006\017\007\014\017\016\014\013\013"
 "\017\014\011\005\220\360\000\000\360\360\100\017\017\003\016\017\017\017\017\017\017\011\100\360\360\000\000\000\360\340\100\006\016\007\001\000\001\007\016\005\100\340\360\000\000\000\000\000"
 "\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360"
 "\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360"
 "\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\007\001\000\001\007\016\005\100\340\360\000\000\000\360\360\100\011\011\016\017\001\006\000\000\007\017"
 "\011\100\360\360\000\000\360\220\005\011\000\017\017\016\017\007\000\016\017\011\005\220\360\000\360\360\020\016\000\000\017\017\001\017\017\017\017\017\000\016\020\360\360\360\260\004\007\000"
 "\000\017\017\000\010\017\017\017\017\000\007\004\260\360\360\200\011\005\006\006\017\017\002\015\015\000\016\017\007\001\011\200\360\360\200\013\010\017\017\017\017\017\017\000\000\016\017\017"
 "\003\013\200\360\360\200\011\005\006\006\017\017\011\017\017\002\016\017\007\002\011\200\360\360\260\004\007\000\000\017\017\000\012\017\017\017\017\000\007\004\260\360\360\360\020\016\000\000"
 "\017\017\000\017\017\015\017\017\000\016\020\360\360\000\360\220\005\011\000\017\017\012\017\003\000\016\017\011\005\220\360\000\000\360\360\100\011\011\017\017\000\006\000\000\011\017\011\100"
 "\360\360\000\000\000\360\340\100\005\017\011\001\000\001\007\016\005\100\340\360\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360"
 "\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000"
 "\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\007"
 "\001\000\006\010\016\005\100\340\360\000\000\000\360\360\100\011\011\000\000\000\012\017\017\002\011\011\100\360\360\000\000\360\220\005\017\017\017\017\017\017\017\017\017\013\014\005\220\360"
 "\000\360\360\020\017\015\015\015\015\015\015\015\015\017\017\017\017\020\360\360\360\260\004\007\000\007\013\000\000\000\000\000\000\016\017\007\004\260\360\360\200\011\001\000\013\017\010\017"
 "\017\017\017\010\017\005\001\011\200\360\360\200\013\000\000\013\017\010\017\017\016\017\010\017\005\000\013\200\360\360\200\011\005\011\017\017\016\017\017\015\017\016\017\015\006\011\200\360"
 "\360\260\004\015\017\017\017\017\017\017\017\017\017\017\017\017\004\260\360\360\360\020\017\001\014\017\012\017\015\011\017\012\017\010\017\020\360\360\000\360\220\005\011\013\017\010\017\017"
 "\017\017\010\017\017\005\220\360\000\000\360\360\100\011\017\017\006\017\017\017\017\007\017\012\100\360\360\000\000\000\360\340\100\005\017\007\001\000\001\007\016\005\100\340\360\000\000\000"
 "\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360"
 "\360\360\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000"
 "\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\007\001\000\007\010\016\005\100\340\360\000\000\000\360\360\100\011\011\000\000\000\012\017\017"
 "\003\011\011\100\360\360\000\000\360\220\005\017\017\017\017\017\017\017\017\017\015\016\005\220\360\000\360\360\020\017\017\017\017\017\017\017\017\017\017\017\017\017\020\360\360\360\260\004"
 "\007\006\017\010\001\000\000\000\000\000\003\013\007\004\260\360\360\200\011\001\002\014\017\012\017\017\017\017\017\017\017\001\011\200\360\360\200\013\000\000\014\016\010\017\016\017\015\017"
 "\017\017\000\013\200\360\360\200\011\001\000\012\014\010\017\012\017\011\017\014\017\001\011\200\360\360\260\004\007\000\016\017\013\017\017\017\017\017\017\017\007\004\260\360\360\360\020\017"
 "\016\007\014\017\017\015\017\014\017\016\017\016\020\360\360\000\360\220\005\017\017\017\016\017\010\017\006\017\012\017\005\220\360\000\000\360\360\100\013\017\017\017\017\004\005\000\005\015"
 "\015\100\360\360\000\000\000\360\340\100\005\017\011\005\001\001\007\016\005\100\340\360\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360"
 "\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000"
 "\000\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005"
 "\016\013\001\000\001\007\016\005\100\340\360\000\000\000\360\360\100\011\011\016\017\013\001\000\016\017\011\011\100\360\360\000\000\360\220\005\017\005\006\017\017\017\017\017\017\005\017\005"
 "\220\360\000\360\360\020\017\017\017\017\017\017\017\017\017\017\017\017\017\020\360\360\360\260\004\011\004\004\004\007\017\017\010\017\017\004\004\011\004\260\360\360\200\011\001\000\000\000"
 "\001\016\003\000\010\013\000\000\001\011\200\360\360\200\013\003\017\017\017\017\017\017\017\017\017\017\014\000\013\200\360\360\200\011\004\017\017\016\017\017\016\017\017\016\017\016\001\011"
 "\200\360\360\260\004\007\007\017\000\012\017\000\015\017\000\017\016\007\004\260\360\360\360\020\016\007\017\000\012\017\000\015\017\000\017\016\016\020\360\360\000\360\220\005\017\017\017\017"
 "\017\017\017\017\017\017\017\005\220\360\000\000\360\360\100\017\017\017\017\017\017\017\017\017\017\015\100\360\360\000\000\000\360\340\100\005\016\007\001\000\001\007\016\005\100\340\360\000"
 "\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360"
 "\360\360\360\360\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000"
 "\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\007\001\000\004\007\016\005\100\340\360\000\000\000\360\360\100\011\011\000\000\000\012"
 "\017\013\000\011\011\100\360\360\000\000\360\220\005\017\012\012\012\012\017\017\017\017\003\011\005\220\360\000\360\360\020\017\017\017\017\017\017\017\017\017\017\017\016\017\020\360\360\360"
 "\260\004\010\002\002\000\000\000\000\011\007\003\016\017\011\004\260\360\360\200\011\001\017\017\000\000\000\000\017\016\000\000\000\001\011\200\360\360\200\013\000\017\017\000\000\000\000\017"
 "\016\000\000\000\000\013\200\360\360\200\011\001\017\017\005\005\005\005\017\017\005\005\005\002\011\200\360\360\260\004\007\017\017\017\017\017\017\017\017\017\017\017\012\004\260\360\360\360"
 "\020\016\017\017\007\007\007\007\017\017\007\007\007\017\020\360\360\000\360\220\005\017\017\000\000\000\000\017\016\000\000\011\005\220\360\000\000\360\360\100\017\017\000\000\000\000\017\016"
 "\000\011\011\100\360\360\000\000\000\360\340\100\005\016\007\001\000\010\014\016\005\100\340\360\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000"
 "\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360"
 "\000\000\000\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340"
 "\100\005\016\007\001\000\001\007\016\005\100\340\360\000\000\000\360\360\100\014\017\015\014\014\014\014\014\015\017\011\100\360\360\000\000\360\220\005\017\017\017\017\017\017\017\017\017\017"
 "\017\005\220\360\000\360\360\020\016\000\017\007\011\017\004\017\004\017\017\017\017\020\360\360\360\260\004\007\000\017\017\017\017\004\017\017\017\012\002\011\004\260\360\360\200\011\001\000"
 "\006\010\010\010\001\006\006\006\001\000\001\011\200\360\360\200\013\000\000\000\017\017\017\017\017\017\017\002\000\000\013\200\360\360\200\011\001\000\000\005\007\007\007\007\014\017\002\000"
 "\001\011\200\360\360\260\004\013\017\017\017\017\017\017\017\017\017\017\017\014\004\260\360\360\360\020\017\015\015\015\017\015\015\015\017\017\017\015\017\020\360\360\000\360\220\005\011\000"
 "\015\017\014\014\014\017\017\002\011\005\220\360\000\000\360\360\100\011\011\005\017\017\017\017\017\017\015\011\100\360\360\000\000\000\360\340\100\005\016\007\001\000\001\007\016\005\100\340"
 "\360\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360"
 "\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000"
 "\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\360\340\100\005\016\007\001\000\001\010\017\005\100\340\360\000\000\000\360\360\100\014\017\003\000"
 "\000\003\017\017\017\014\011\100\360\360\000\000\360\220\005\017\017\017\017\015\014\017\017\014\012\017\005\220\360\000\360\360\020\016\000\001\017\017\017\017\017\017\017\017\017\017\020\360"
 "\360\360\260\004\007\000\014\017\015\000\000\017\017\017\001\000\007\004\260\360\360\200\011\001\000\002\013\000\000\000\004\017\016\000\000\001\011\200\360\360\200\013\000\016\017\017\017\017"
 "\017\017\017\017\012\001\000\013\200\360\360\200\011\003\017\015\007\013\017\010\017\017\017\017\017\007\011\200\360\360\260\004\012\017\005\000\003\017\017\017\013\013\017\012\010\004\260\360"
 "\360\360\020\017\017\005\002\015\015\014\014\006\013\017\000\016\020\360\360\000\360\220\005\017\012\012\017\017\016\015\015\017\017\011\005\220\360\000\000\360\360\100\016\017\013\012\016\017"
 "\017\017\017\017\011\100\360\360\000\000\000\360\340\100\005\016\007\001\000\001\007\016\005\100\340\360\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000"
 "\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360\360\360\000\000\000\000\000\000\000\000\000\000\000\000\360\360\360\360\360"
 "\360\360\000\000\000\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000"
 "\360\340\100\005\016\011\002\000\001\007\016\005\100\340\360\000\000\000\360\360\100\012\013\000\017\011\000\000\000\000\011\011\100\360\360\000\000\360\220\006\017\015\000\017\011\000\000\000"
 "\000\000\011\005\220\360\000\360\360\020\016\015\017\006\017\017\017\017\017\017\017\011\016\020\360\360\360\260\004\007\001\017\017\017\017\016\017\017\016\017\012\007\004\260\360\360\200\011"
 "\001\000\007\003\017\011\000\013\017\000\017\014\001\011\200\360\360\200\013\000\000\000\000\017\011\000\013\017\000\017\016\000\013\200\360\360\200\011\001\000\003\001\017\012\000\014\017\000"
 "\017\017\001\011\200\360\360\260\004\007\000\017\017\017\017\017\017\017\000\015\017\007\004\260\360\360\360\020\016\010\017\012\017\017\014\017\017\000\012\017\017\020\360\360\000\360\220\006"
 "\017\017\001\017\011\000\013\017\000\006\017\005\220\360\000\000\360\360\100\014\015\000\017\011\000\004\010\000\011\011\100\360\360\000\000\000\360\340\100\005\016\013\003\000\001\007\016\005"
 "\100\340\360\000\000\000\000\000\360\360\220\020\004\011\013\011\004\020\220\360\360\000\000\000\000\000\000\000\360\360\360\260\200\200\200\260\360\360\360\000\000\000\000\000\000\000\000\000"
 "\000\360\360\360\360\360\360\360\000\000\000\000\000\000";
const uint8_t CHS_A[] PROGMEM =
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\023\077\054\002\000\000\000\000\000\000\000\000\000\000\000\000\000\000\142\377\377\341\140\000\000\000\000\000\000\000\000\000\000\000\000\000\142\377\377\377"
 "\377\205\000\000\000\000\000\000\000\000\000\000\000\000\142\377\377\377\377\376\110\207\260\166\007\000\000\000\000\000\000\000\142\377\377\377\377\377\375\377\377\377\245\065\112\000\000\000"
 "\000\000\142\377\377\377\377\377\377\377\377\377\375\374\377\132\000\000\000\000\142\377\377\377\377\377\377\377\377\377\376\376\377\134\000\000\000\000\142\377\377\377\377\377\377\377\377\377"
 "\254\076\122\001\000\000\000\000\142\377\377\377\377\376\120\223\273\177\011\000\000\000\000\000\000\000\142\377\377\377\377\214\000\000\000\000\000\000\000\000\000\000\000\000\142\377\377\350"
 "\152\001\000\000\000\000\000\000\000\000\000\000\000\000\026\111\066\005\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\005\303\303\212\137\117\040\000\000\000\000\000\000\000\000\042\152\072\071\316\277\377\377\377\344\227\153\073\000\000\000"
 "\000\000\140\377\377\255\354\377\377\377\377\265\377\371\117\000\000\000\000\000\140\377\377\377\272\362\377\377\377\377\377\167\027\000\000\000\000\000\140\377\377\377\374\311\375\377\377\377"
 "\377\373\370\100\000\000\000\000\140\377\377\377\377\377\377\377\377\342\277\177\102\000\000\000\000\000\140\377\377\377\377\377\377\377\340\222\144\000\000\000\000\000\000\000\140\377\377\377"
 "\377\377\356\234\231\123\000\000\000\000\000\000\000\000\140\312\272\242\203\204\212\175\025\000\000\000\000\000\000\000\000\000\140\233\222\216\204\110\006\000\000\000\000\000\000\000\000\000"
 "\000\000\005\003\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\002\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\134\204\006\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\140\377\322\062\000\000\015\204\267\201"
 "\013\000\000\000\000\000\000\000\140\377\377\372\346\347\321\377\033\377\261\065\115\001\000\000\000\000\140\377\377\377\377\377\374\204\011\204\372\373\377\121\000\000\000\000\140\377\377\377"
 "\377\377\374\167\010\167\372\375\377\124\000\000\000\000\140\377\377\371\353\361\331\377\022\377\271\100\130\002\000\000\000\000\140\377\323\061\002\003\021\222\303\217\017\000\000\000\000\000"
 "\000\000\136\214\010\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\004\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\136\270\002\000\000\000\000\000\000\000"
 "\000\000\333\164\000\000\000\000\144\207\245\272\075\044\044\044\044\065\272\363\376\173\000\000\000\000\144\207\052\340\377\377\377\377\377\377\260\270\160\052\000\000\000\000\144\207\052\340"
 "\377\377\377\377\377\377\223\236\121\030\000\000\000\000\144\207\052\340\377\377\377\377\377\377\223\236\377\173\000\000\000\000\144\207\052\340\377\377\377\377\377\377\223\236\377\173\000\000"
 "\000\000\144\207\052\340\377\377\377\377\377\377\223\236\117\027\000\000\000\000\144\207\052\340\377\377\377\377\377\377\252\263\160\052\000\000\000\000\144\207\245\303\111\063\063\063\063\103"
 "\305\375\377\173\000\000\000\000\142\275\002\000\000\000\000\000\000\000\000\000\345\171\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\147\322\014\000\000\000\000\000\000\000\000\000\000\000\000\033\152\237\246\340\016\000\000\000\000\000\000\112\262\304\274"
 "\272\321\331\145\007\000\000\200\206\000\000\000\000\000\140\122\377\260\243\331\231\251\274\317\311\335\304\000\000\000\000\000\140\122\377\260\271\377\350\250\150\050\000\007\007\000\000\000"
 "\000\000\140\122\377\260\301\315\226\210\173\155\140\124\315\076\000\000\000\000\140\122\377\260\301\316\251\235\221\206\172\160\354\111\000\000\000\000\140\122\377\260\272\377\330\230\130\031"
 "\000\003\003\000\000\000\000\000\140\122\377\260\243\334\206\212\254\315\310\335\275\000\000\000\000\000\075\212\243\230\226\261\357\227\036\000\000\223\220\000\000\000\000\000\000\000\000\000"
 "\000\000\014\132\254\263\322\013\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\151\337\015\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\016\037\003\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\023\245\334\304\336\134\000\000\000\000\000\000\000\000\000\000\000\001\314\221\243\307\207\314\104\000\000\000\000\000\000\000\131\306\264\272\333\251\377\377\377\207\261\000\000\000\000\000"
 "\000\000\140\202\307\162\316\300\377\377\377\213\320\000\000\000\000\000\000\000\140\220\377\215\316\277\375\375\365\172\300\010\066\000\000\000\000\000\140\220\377\215\352\223\223\223\223\311"
 "\111\233\304\050\000\000\000\000\140\220\377\215\355\242\242\242\242\312\073\240\312\056\000\000\000\000\140\220\377\215\316\264\356\356\346\173\304\014\077\000\000\000\000\000\140\205\326\171"
 "\316\300\377\377\377\213\317\000\000\000\000\000\000\000\137\313\264\272\330\255\377\377\377\210\265\000\000\000\000\000\000\000\000\000\000\002\324\212\261\326\216\305\113\000\000\000\000\000"
 "\000\000\000\000\000\000\032\262\323\270\340\150\000\000\000\000\000\000\000\000\000\000\000\000\000\000\027\054\007\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\023\077\054\002\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\142\377\377\341\140\000\000\000\000\000\000\000\000\000\000\000\000\000\142\377\377\377\377\205\000\000\000\000\000\000\000\000\000\000\000\000\142\377\377\377\377\376\110\207\260\166"
 "\007\000\000\000\000\000\000\000\142\377\377\377\377\377\375\377\377\377\245\065\112\000\000\000\000\000\142\377\377\377\377\377\377\377\377\377\375\374\377\132\000\000\000\000\142\377\377\377"
 "\377\377\377\377\377\377\376\376\377\134\000\000\000\000\142\377\377\377\377\377\377\377\377\377\254\076\122\001\000\000\000\000\142\377\377\377\377\376\120\223\273\177\011\000\000\000\000\000"
 "\000\000\142\377\377\377\377\214\000\000\000\000\000\000\000\000\000\000\000\000\142\377\377\350\152\001\000\000\000\000\000\000\000\000\000\000\000\000\026\111\066\005\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\005\303\303\212\137\117\040"
 "\000\000\000\000\000\000\000\000\042\152\072\071\316\277\377\377\377\344\227\153\073\000\000\000\000\000\140\377\377\255\354\377\377\377\377\265\377\371\117\000\000\000\000\000\140\377\377\377"
 "\272\362\377\377\377\377\377\167\027\000\000\000\000\000\140\377\377\377\374\311\375\377\377\377\377\373\370\100\000\000\000\000\140\377\377\377\377\377\377\377\377\342\277\177\102\000\000\000"
 "\000\000\140\377\377\377\377\377\377\377\340\222\144\000\000\000\000\000\000\000\140\377\377\377\377\377\356\234\231\123\000\000\000\000\000\000\000\000\140\312\272\242\203\204\212\175\025\000"
 "\000\000\000\000\000\000\000\000\140\233\222\216\204\110\006\000\000\000\000\000\000\000\000\000\000\000\005\003\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\002\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\134\204\006\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\140\377\322\062\000\000\015\204\267\201\013\000\000\000\000\000\000\000\140\377\377\372\346\347\321\377\033\377\261\065\115\001\000\000"
 "\000\000\140\377\377\377\377\377\374\204\011\204\372\373\377\121\000\000\000\000\140\377\377\377\377\377\374\167\010\167\372\375\377\124\000\000\000\000\140\377\377\371\353\361\331\377\022\377"
 "\271\100\130\002\000\000\000\000\140\377\323\061\002\003\021\222\303\217\017\000\000\000\000\000\000\000\136\214\010\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\004\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\136\270\002\000\000\000\000\000\000\000\000\000\333\164\000\000\000\000\144\207\245\272\075\044\044\044\044\065\272\363\376\173\000\000"
 "\000\000\144\207\052\340\377\377\377\377\377\377\260\270\160\052\000\000\000\000\144\207\052\340\377\377\377\377\377\377\223\236\121\030\000\000\000\000\144\207\052\340\377\377\377\377\377\377"
 "\223\236\377\173\000\000\000\000\144\207\052\340\377\377\377\377\377\377\223\236\377\173\000\000\000\000\144\207\052\340\377\377\377\377\377\377\223\236\117\027\000\000\000\000\144\207\052\340"
 "\377\377\377\377\377\377\252\263\160\052\000\000\000\000\144\207\245\303\111\063\063\063\063\103\305\375\377\173\000\000\000\000\142\275\002\000\000\000\000\000\000\000\000\000\345\171\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\147\322\014\000\000\000\000"
 "\000\000\000\000\000\000\000\000\033\152\237\246\340\016\000\000\000\000\000\000\112\262\304\274\272\321\331\145\007\000\000\200\206\000\000\000\000\000\140\122\377\260\243\331\231\251\274\317"
 "\311\335\304\000\000\000\000\000\140\122\377\260\271\377\350\250\150\050\000\007\007\000\000\000\000\000\140\122\377\260\301\315\226\210\173\155\140\124\315\076\000\000\000\000\140\122\377\260"
 "\301\316\251\235\221\206\172\160\354\111\000\000\000\000\140\122\377\260\272\377\330\230\130\031\000\003\003\000\000\000\000\000\140\122\377\260\243\334\206\212\254\315\310\335\275\000\000\000"
 "\000\000\075\212\243\230\226\261\357\227\036\000\000\223\220\000\000\000\000\000\000\000\000\000\000\000\014\132\254\263\322\013\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\151"
 "\337\015\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\016\037\003\000\000\000\000\000\000\000\000\000\000\000\000\000\023\245\334\304\336\134\000\000\000\000\000\000\000\000\000\000\000\001\314\221\243\307\207\314"
 "\104\000\000\000\000\000\000\000\131\306\264\272\333\251\377\377\377\207\261\000\000\000\000\000\000\000\140\202\307\162\316\300\377\377\377\213\320\000\000\000\000\000\000\000\140\220\377\215"
 "\316\277\375\375\365\172\300\010\066\000\000\000\000\000\140\220\377\215\352\223\223\223\223\311\111\233\304\050\000\000\000\000\140\220\377\215\355\242\242\242\242\312\073\240\312\056\000\000"
 "\000\000\140\220\377\215\316\264\356\356\346\173\304\014\077\000\000\000\000\000\140\205\326\171\316\300\377\377\377\213\317\000\000\000\000\000\000\000\137\313\264\272\330\255\377\377\377\210"
 "\265\000\000\000\000\000\000\000\000\000\000\002\324\212\261\326\216\305\113\000\000\000\000\000\000\000\000\000\000\000\032\262\323\270\340\150\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\027\054\007\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000";
const uint8_t CHS_T[] PROGMEM =
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\373\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\377\377\000\044"
 "\367\377\000\000\000\000\000\000\000\000\000\000\000\000\377\377\000\000\011\377\377\377\377\377\377\000\000\000\000\000\000\000\377\377\000\000\000\155\377\237\106\310\377\377\377\377\000\000"
 "\000\000\377\377\000\000\000\032\356\000\000\001\377\377\377\377\000\000\000\000\377\377\000\000\000\030\352\000\000\000\377\377\375\377\000\000\000\000\377\377\000\000\000\152\377\221\073\272"
 "\377\377\377\377\000\000\000\000\377\377\000\000\007\377\377\377\377\377\377\000\000\000\000\000\000\000\377\377\000\034\356\377\000\000\000\000\000\000\000\000\000\000\000\000\377\377\357\377"
 "\377\377\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377\000\000\000\000\000\000\000\000\377\377\377\377\377\377\156\073\266\377\377\377\377\000\000\000"
 "\000\000\377\133\273\377\377\177\021\000\165\377\353\377\377\000\000\000\000\000\377\053\000\204\377\351\000\000\010\157\122\377\377\000\000\000\000\000\377\053\000\001\330\377\212\000\000\034"
 "\205\377\377\377\000\000\000\000\377\053\000\000\005\173\124\000\037\377\377\377\377\000\000\000\000\000\377\053\000\000\000\000\000\122\377\377\377\000\000\000\000\000\000\000\377\053\000\000"
 "\046\200\366\377\377\377\000\000\000\000\000\000\000\000\377\367\377\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000"
 "\000\000\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\314\377\377\000\000\377\377\377\377"
 "\377\000\000\000\000\000\000\000\377\075\060\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\075\000\002\010\000\327\377\377\377\377\324\260\377\000\000\000\000\377\075\000\000"
 "\003\000\323\377\377\377\377\305\244\377\000\000\000\000\377\075\043\354\377\362\377\377\377\377\377\377\377\377\000\000\000\000\377\271\377\377\377\377\377\377\377\377\377\000\000\000\000\000"
 "\000\000\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\000\000\000\000\000\000\000"
 "\000\000\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\342\335\173\173\173\173\333\377\377\377\377\000\000\000\000\377\377\377\304"
 "\232\000\000\000\000\230\377\377\377\377\000\000\000\000\377\377\377\304\232\000\000\000\000\230\377\377\377\377\000\000\000\000\377\377\377\304\232\000\000\000\000\230\377\377\377\377\000\000"
 "\000\000\377\377\377\304\232\000\000\000\000\230\377\377\377\377\000\000\000\000\377\377\377\335\322\147\147\147\147\320\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\000\000\000\000\377\377\377\000\000\000\000\000\000\000\000\000\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\000\000\000\000\000\000\377\377\377\377"
 "\377\377\377\377\377\000\000\377\377\000\000\000\000\000\377\377\367\371\377\377\377\377\377\377\377\377\377\000\000\000\000\000\377\377\367\371\377\245\354\377\377\377\377\377\377\000\000\000"
 "\000\000\377\377\367\371\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\367\371\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\367\371\377\377\377\377\377\377"
 "\000\377\377\000\000\000\000\000\377\377\367\371\377\377\377\377\377\377\377\377\377\000\000\000\000\000\377\377\377\377\377\377\377\377\377\000\377\377\377\000\000\000\000\000\000\000\000\000"
 "\000\000\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\000\000\000\000\000\000\000\377\377\377\377\377\377\075\000\262\377\377\000\000\000\000\000"
 "\000\000\377\377\377\377\377\345\000\000\062\377\377\000\000\000\000\000\000\000\377\377\140\377\377\377\255\255\377\377\377\377\377\000\000\000\000\000\377\377\140\377\377\377\377\377\377\377"
 "\377\377\377\377\000\000\000\000\377\377\140\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\140\377\377\377\270\270\377\377\377\377\377\000\000\000\000\000\377\377\363\377"
 "\377\344\000\000\066\377\377\000\000\000\000\000\000\000\377\377\377\377\377\377\061\000\241\377\377\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\000\000\000\000\000"
 "\000\000\000\000\000\000\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377"
 "\377\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000"
 "\000\000\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377"
 "\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000"
 "\000\000\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\377\000"
 "\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\000\000\377\377\377\377\377\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000"
 "\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000\000\000\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\000\000\000\000\000\000\000\000\000\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000"
 "\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\000\000\000\000\000\000\000\000\000\377\377\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\000\000\000\000"
 "\000\000\000\000\000\000\000\000\377\377\377\377\377\377\000\000\000\000\000\000\377\377\377\377\377\377\377\377\377\000\000\377\377\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377"
 "\377\377\377\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\000\377\377\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000"
 "\000\000\377\377\377\377\377\377\377\377\377\000\377\377\377\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\377"
 "\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\000\000\000\000\000\000\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377"
 "\377\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000\000\000\377\377\377\377"
 "\377\377\377\377\377\377\377\377\377\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000"
 "\000\000\377\377\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377\377\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\377\377"
 "\377\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\377\377\377\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000"
 "\000\000\377\377\377\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000\000";
static const uint16_t CH_TINY[16] = { 0x2C97, 0x73E7, 0x73CF, 0x5BC9, 0x79CF, 0x79EF, 0x7252, 0x7BEF, 0x2BED, 0x6BAE, 0x3923, 0x6B6E, 0x79A7, 0x79A4, 0x396B, 0x5BED };
static inline uint16_t spRGB(int r, int g, int b) { return (uint16_t)(((r & 0xF8) << 8) | ((g & 0xFC) << 3) | (b >> 3)); }
static inline void spUnpack(uint16_t c, int &r, int &g, int &b) { r = (c >> 11) << 3; g = ((c >> 5) & 63) << 2; b = (c & 31) << 3; }
static void chSprite(int gx, int gy, int idx, uint16_t bgc) {
 const uint8_t *A = CHS_A + idx * 324, *T = CHS_T + idx * 324;
 int br, bg, bb; spUnpack(bgc, br, bg, bb);
 int fb = (idx >= 6) ? 255 : 232;
 for (int y = 0; y < 18; y++) for (int x = 0; x < 18; x++) {
 int a = pgm_read_byte(A + y * 18 + x); if (!a) continue;
 int t = pgm_read_byte(T + y * 18 + x);
 int r = 255 * (255 - t) / 255, g = r, b = fb * (255 - t) / 255;
 if (a < 255) { r = (r * a + br * (255 - a)) / 255; g = (g * a + bg * (255 - a)) / 255; b = (b * a + bb * (255 - a)) / 255; }
 gfx->drawPixel(gx + x, gy + y, spRGB(r, g, b));
 }
}
static void xqSprite(int gx, int gy, int idx, uint16_t bgc) {
 const uint8_t *A = XQS_A + idx * 361, *B = XQS_B + idx * 361;
 int br, bg, bb; spUnpack(bgc, br, bg, bb);
 const int fr = 217, fg = 186, fb = 140;
 const int ir = (idx >= 7) ? 163 : 0, ig = (idx >= 7) ? 6 : 0, ib = (idx >= 7) ? 1 : 0;
 for (int y = 0; y < 19; y++) for (int x = 0; x < 19; x++) {
 int a = pgm_read_byte(A + y * 19 + x); if (!a) continue;
 int v = pgm_read_byte(B + y * 19 + x);
 int kb = v >> 4, ki = v & 15, kf = 15 - kb - ki; if (kf < 0) { kf = 0; }
 int r = (fr * kf + ir * ki) / 15, g = (fg * kf + ig * ki) / 15, b = (fb * kf + ib * ki) / 15;
 if (a < 255) { r = (r * a + br * (255 - a)) / 255; g = (g * a + bg * (255 - a)) / 255; b = (b * a + bb * (255 - a)) / 255; }
 gfx->drawPixel(gx + x, gy + y, spRGB(r, g, b));
 }
}
#define CH_CELL 20
#define CH_BX 1
#define CH_BY 1
#define CH_BW 168
#define CH_GX 5
#define CH_GY 5
#define CH_PX 174
#define CH_PW 144
#define CH_MAXH 700
static int chMode = 1, chSel = -1, chRes = 0;
static bool chTgt[64], chChk = false, chPend = false;
static unsigned long chAiAt = 0;
static ChUn chHist[CH_MAXH];
static int chHn = 0;
static void chRefresh() {
 ChMv l[256]; int n = chLegal(l);
 chChk = chInCheck(chSide); chRes = 0;
 if (!n) chRes = chChk ? (chSide > 0 ? 2 : 1) : 3;
 else if (chHalf >= 100 || chInsufficient() || chHn >= CH_MAXH) chRes = 3;
 chSel = -1; memset(chTgt, 0, sizeof(chTgt));
 chPend = (chRes == 0 && chMode < 3 && chSide < 0);
 chAiAt = millis() + 200;
}
static void chReset() { chSetup(); chHn = 0; chRefresh(); chPend = false; }
static void chPlay(const ChMv &m) { if (chHn < CH_MAXH) chMake(m, chHist[chHn++]); }
static inline int chCx(int sq) { return CH_GX + (7 - (sq >> 3)) * CH_CELL; }
static inline int chCy(int sq) { return CH_GY + (sq & 7) * CH_CELL; }
static void chTiny(int cgx, int cgy, int vx, int vy, int glyph, uint16_t col) {
 uint16_t g = CH_TINY[glyph];
 for (int py = 0; py < 5; py++) for (int px = 0; px < 3; px++)
 if (g & (1 << (14 - (py * 3 + px)))) gfx->drawPixel(cgx + CH_CELL - 1 - (vy + py), cgy + vx + px, col);
}
static void chDraw() {
 UiCanvasGuard _g;
 gfx->fillScreen(MG_BG);
 const uint16_t LIGHT = MGC(255, 253, 254), DARKC = MGC(220, 211, 201);
 gfx->fillRect(CH_BX, CH_BY, CH_BW, CH_BW, MGC(50, 32, 20));
 int lf = chHn ? chHist[chHn - 1].f : -1, lt = chHn ? chHist[chHn - 1].t : -1;
 int ks = chChk ? chKingSq(chSide) : -1;
 uint16_t cc[64];
 for (int sq = 0; sq < 64; sq++) {
 int r = sq >> 3, c = sq & 7;
 bool dark = (r + c) & 1;
 uint16_t col = dark ? DARKC : LIGHT;
 if (sq == lf || sq == lt) col = dark ? MGC(214, 196, 70) : MGC(246, 240, 140);
 if (sq == ks) col = MGC(230, 60, 60);
 if (sq == chSel) col = MGC(90, 200, 255);
 cc[sq] = col;
 gfx->fillRect(chCx(sq), chCy(sq), CH_CELL, CH_CELL, col);
 }
 for (int sq = 0; sq < 64; sq++) {
 int r = sq >> 3, c = sq & 7;
 bool dark = (r + c) & 1;
 uint16_t lab = dark ? LIGHT : DARKC;
 if (c == 0) chTiny(chCx(sq), chCy(sq), 1, 1, 7 - r, lab);
 if (r == 7) chTiny(chCx(sq), chCy(sq), CH_CELL - 4, CH_CELL - 6, 8 + c, lab);
 }
 for (int sq = 0; sq < 64; sq++) {
 int r = sq >> 3, c = sq & 7, x = chCx(sq), y = chCy(sq);
 if (chB[sq]) chSprite(x + 1, y + 1, (chB[sq] > 0 ? 0 : 6) + chAbs(chB[sq]) - 1, cc[sq]);
 if (chTgt[sq]) {
 if (chB[sq]) { gfx->drawRect(x, y, CH_CELL, CH_CELL, MGC(230, 40, 40)); gfx->drawRect(x + 1, y + 1, CH_CELL - 2, CH_CELL - 2, MGC(230, 40, 40)); }
 else gfx->fillCircle(x + CH_CELL / 2, y + CH_CELL / 2, 4, MGC(40, 150, 70));
 }
 (void)r; (void)c;
 }
 bool vs = chMode < 3;
 String l2, l3; uint16_t c2 = MG_TXT;
 String turn = vs ? String(chSide > 0 ? tr("Your turn", "Lượt bạn") : tr("CPU turn", "Máy đi")) : String(chSide > 0 ? tr("White", "Trắng đi") : tr("Black", "Đen đi"));
 if (chRes == 1 || chRes == 2) {
 l2 = tr("Checkmate!", "Chiếu hết!"); c2 = CX_GOLD;
 l3 = (chRes == 1) ? (vs ? String(tr("You win!", "Bạn thắng!")) : String(tr("White wins", "Trắng thắng"))) : (vs ? String(tr("CPU wins", "Máy thắng")) : String(tr("Black wins", "Đen thắng")));
 } else if (chRes == 3) { l2 = tr("Draw", "Hòa"); c2 = CX_GOLD; l3 = tr("Tap New", "Bấm Mới"); }
 else {
 if (chChk) { l2 = tr("CHECK!", "CHIẾU!"); c2 = CX_ALERT; } else l2 = turn;
 l3 = mgThinking ? String(tr("Thinking...", "Đang nghĩ...")) : (chChk ? turn : String(""));
 }
 cxStatus(CH_PX, tr("Chess", "Cờ vua"), l2, c2, l3);
 cxPanel(CH_PX, CH_PW, chMode);
}
static void chSelect(int sq) {
 chSel = sq; memset(chTgt, 0, sizeof(chTgt));
 ChMv l[256]; int n = chLegal(l);
 for (int i = 0; i < n; i++) if (l[i].f == sq) chTgt[l[i].t] = true;
}
static void chUndo() {
 if (!chHn) return;
 chUnmake(chHist[--chHn]);
 if (chMode < 3 && chSide < 0 && chHn) chUnmake(chHist[--chHn]);
 chRefresh(); chPend = false;
}
static void chLoop(bool key) {
 (void)key;
 if (chPend && (long)(millis() - chAiAt) >= 0) {
 mgThinking = true; chDraw();
 ChMv m; bool ok = chBest(chMode, m);
 mgThinking = false;
 if (ok) chPlay(m);
 chRefresh(); chDraw(); return;
 }
 if (!mgT.pressed) return;
 int x = mgT.sx, y = mgT.sy;
 int b = cxHit(x, y, CH_PX, CH_PW);
 if (b == CX_BTN_MODE) { chMode = (chMode + 1) % 4; chReset(); chDraw(); return; }
 if (b == CX_BTN_UNDO) { chUndo(); chDraw(); return; }
 if (b == CX_BTN_NEW) { chReset(); chDraw(); return; }
 if (b == CX_BTN_EXIT) { mgExit(); return; }
 if (chRes || chPend || !mgIn(x, y, CH_BX, CH_BY, CH_BW, CH_BW)) return;
 x = constrain(x, CH_GX, CH_GX + 8 * CH_CELL - 1); y = constrain(y, CH_GY, CH_GY + 8 * CH_CELL - 1);
 int sq = (7 - (x - CH_GX) / CH_CELL) * 8 + (y - CH_GY) / CH_CELL;
 if (chSel >= 0 && chTgt[sq]) {
 ChMv l[256]; int n = chLegal(l);
 for (int i = 0; i < n; i++) if (l[i].f == chSel && l[i].t == sq) { chPlay(l[i]); break; }
 chRefresh(); chDraw(); return;
 }
 int p = chB[sq];
 if (p && (p > 0) == (chSide > 0)) chSelect(sq); else { chSel = -1; memset(chTgt, 0, sizeof(chTgt)); }
 chDraw();
}
#define XQ_SP 19
#define XQ_X0 12
#define XQ_Y0 9
#define XQ_PX 196
#define XQ_PW 122
#define XQ_MAXH 700
static int xqMode = 1, xqSel = -1, xqRes = 0;
static bool xqTgt[90], xqChk = false, xqPend = false;
static unsigned long xqAiAt = 0;
static XqUn xqHist[XQ_MAXH];
static int xqHn = 0;
static inline int xqPx(int r) { return XQ_X0 + (9 - r) * XQ_SP; }
static inline int xqPy(int c) { return XQ_Y0 + c * XQ_SP; }
static void xqRefresh() {
 XqMv l[128]; int n = xqLegal(l);
 xqChk = xqInCheck(xqSide); xqRes = 0;
 if (!n) xqRes = (xqSide > 0) ? 2 : 1;
 else if (xqHalf >= 120 || xqHn >= XQ_MAXH) xqRes = 3;
 xqSel = -1; memset(xqTgt, 0, sizeof(xqTgt));
 xqPend = (xqRes == 0 && xqMode < 3 && xqSide < 0);
 xqAiAt = millis() + 200;
}
static void xqReset() { xqSetup(); xqHn = 0; xqRefresh(); xqPend = false; }
static void xqPlay(const XqMv &m) { if (xqHn < XQ_MAXH) xqMake(m, xqHist[xqHn++]); }
static const uint8_t XQ_SPR[8] = { 0, 6, 3, 2, 1, 5, 0, 4 };
static void xqPiece(int cx, int cy, int p) {
 xqSprite(cx - 9, cy - 9, (p > 0 ? 7 : 0) + XQ_SPR[chAbs(p)], MGC(214, 150, 53));
}
static void xqDraw() {
 UiCanvasGuard _g;
 gfx->fillScreen(MG_BG);
 const uint16_t MARGIN = MGC(176, 79, 0), BOARDC = MGC(214, 150, 53), LINE = MGC(0, 0, 0);
 gfx->fillRect(2, 0, 192, 170, MARGIN);
 gfx->fillRect(xqPx(9), xqPy(0), 9 * XQ_SP + 1, 8 * XQ_SP + 1, BOARDC);
 for (int c = 0; c < 9; c++) {
 int y = xqPy(c);
 if (c == 0 || c == 8) gfx->drawFastHLine(xqPx(9), y, 9 * XQ_SP + 1, LINE);
 else { gfx->drawFastHLine(xqPx(9), y, 4 * XQ_SP + 1, LINE); gfx->drawFastHLine(xqPx(4), y, 4 * XQ_SP + 1, LINE); }
 }
 for (int r = 0; r < 10; r++) gfx->drawFastVLine(xqPx(r), xqPy(0), 8 * XQ_SP + 1, LINE);
 gfx->drawLine(xqPx(7), xqPy(3), xqPx(9), xqPy(5), LINE); gfx->drawLine(xqPx(7), xqPy(5), xqPx(9), xqPy(3), LINE);
 gfx->drawLine(xqPx(0), xqPy(3), xqPx(2), xqPy(5), LINE); gfx->drawLine(xqPx(0), xqPy(5), xqPx(2), xqPy(3), LINE);
 int lf = xqHn ? xqHist[xqHn - 1].f : -1, lt = xqHn ? xqHist[xqHn - 1].t : -1;
 int ks = xqChk ? xqKingSq(xqSide) : -1;
 uint16_t HL = MGC(40, 160, 230);
 if (lf >= 0) { gfx->drawCircle(xqPx(lf / 9), xqPy(lf % 9), 10, HL); gfx->drawCircle(xqPx(lt / 9), xqPy(lt % 9), 10, HL); gfx->drawCircle(xqPx(lt / 9), xqPy(lt % 9), 11, HL); }
 if (ks >= 0) gfx->fillCircle(xqPx(ks / 9), xqPy(ks % 9), 11, MGC(230, 60, 60));
 if (xqSel >= 0) gfx->fillCircle(xqPx(xqSel / 9), xqPy(xqSel % 9), 11, MGC(60, 210, 255));
 for (int sq = 0; sq < 90; sq++) if (xqB[sq]) xqPiece(xqPx(sq / 9), xqPy(sq % 9), xqB[sq]);
 for (int sq = 0; sq < 90; sq++) if (xqTgt[sq]) {
 int x = xqPx(sq / 9), y = xqPy(sq % 9);
 if (xqB[sq]) { gfx->drawCircle(x, y, 10, MGC(230, 40, 40)); gfx->drawCircle(x, y, 11, MGC(230, 40, 40)); gfx->drawCircle(x, y, 12, MGC(230, 40, 40)); }
 else gfx->fillCircle(x, y, 4, MGC(40, 150, 70));
 }
 bool vs = xqMode < 3;
 String l2, l3; uint16_t c2 = MG_TXT;
 String turn = vs ? String(xqSide > 0 ? tr("Your turn", "Lượt bạn") : tr("CPU turn", "Máy đi")) : String(xqSide > 0 ? tr("Red", "Đỏ đi") : tr("Black", "Đen đi"));
 if (xqRes == 1 || xqRes == 2) {
 l2 = tr("Checkmate!", "Chiếu bí!"); c2 = CX_GOLD;
 l3 = (xqRes == 1) ? (vs ? String(tr("You win!", "Bạn thắng!")) : String(tr("Red wins", "Đỏ thắng"))) : (vs ? String(tr("CPU wins", "Máy thắng")) : String(tr("Black wins", "Đen thắng")));
 } else if (xqRes == 3) { l2 = tr("Draw", "Hòa"); c2 = CX_GOLD; l3 = tr("Tap New", "Bấm Mới"); }
 else {
 if (xqChk) { l2 = tr("CHECK!", "CHIẾU!"); c2 = CX_ALERT; } else l2 = turn;
 l3 = mgThinking ? String(tr("Thinking...", "Đang nghĩ...")) : (xqChk ? turn : String(""));
 }
 cxStatus(XQ_PX, tr("Xiangqi", "Cờ tướng"), l2, c2, l3);
 cxPanel(XQ_PX, XQ_PW, xqMode);
}
static void xqSelect(int sq) {
 xqSel = sq; memset(xqTgt, 0, sizeof(xqTgt));
 XqMv l[128]; int n = xqLegal(l);
 for (int i = 0; i < n; i++) if (l[i].f == sq) xqTgt[l[i].t] = true;
}
static void xqUndo() {
 if (!xqHn) return;
 xqUnmake(xqHist[--xqHn]);
 if (xqMode < 3 && xqSide < 0 && xqHn) xqUnmake(xqHist[--xqHn]);
 xqRefresh(); xqPend = false;
}
static void xqLoop(bool key) {
 (void)key;
 if (xqPend && (long)(millis() - xqAiAt) >= 0) {
 mgThinking = true; xqDraw();
 XqMv m; bool ok = xqBest(xqMode, m);
 mgThinking = false;
 if (ok) xqPlay(m);
 xqRefresh(); xqDraw(); return;
 }
 if (!mgT.pressed) return;
 int x = mgT.sx, y = mgT.sy;
 int b = cxHit(x, y, XQ_PX, XQ_PW);
 if (b == CX_BTN_MODE) { xqMode = (xqMode + 1) % 4; xqReset(); xqDraw(); return; }
 if (b == CX_BTN_UNDO) { xqUndo(); xqDraw(); return; }
 if (b == CX_BTN_NEW) { xqReset(); xqDraw(); return; }
 if (b == CX_BTN_EXIT) { mgExit(); return; }
 if (xqRes || xqPend || x >= XQ_PX - 4) return;
 int c = (y - XQ_Y0 + XQ_SP / 2) / XQ_SP, rx = (x - XQ_X0 + XQ_SP / 2) / XQ_SP;
 if (y < XQ_Y0 - XQ_SP / 2 || x < XQ_X0 - XQ_SP / 2 || c < 0 || c > 8 || rx < 0 || rx > 9) return;
 int sq = (9 - rx) * 9 + c;
 if (xqSel >= 0 && xqTgt[sq]) {
 XqMv l[128]; int n = xqLegal(l);
 for (int i = 0; i < n; i++) if (l[i].f == xqSel && l[i].t == sq) { xqPlay(l[i]); break; }
 xqRefresh(); xqDraw(); return;
 }
 int p = xqB[sq];
 if (p && (p > 0) == (xqSide > 0)) xqSelect(sq); else { xqSel = -1; memset(xqTgt, 0, sizeof(xqTgt)); }
 xqDraw();
}
#define RN_SKY_TOP MGC(120, 150, 205)
#define RN_SKY_BOT MGC(255, 224, 178)
#define RN_SUN MGC(255, 196, 102)
#define RN_SUN_CORE MGC(255, 246, 216)
#define RN_CLOUD 0xFFFF
#define RN_CLOUD_SHADE MGC(226, 222, 240)
#define RN_SAND_TOP MGC(237, 201, 140)
#define RN_SAND_MID MGC(214, 168, 105)
#define RN_SAND_BOT MGC(168, 124, 74)
#define RN_SPRITE MGC(83, 83, 83)
#define RN_DINO_X 30
#define RN_DINO_W 22
#define RN_DINO_H 24
#define RN_CAC_W 10
#define RN_CAC_TOP 14
static const uint32_t RN_DINO_SPR[] PROGMEM = {
 0x0003FE, 0x0007FF, 0x00077F, 0x0007FF, 0x0007FF, 0x0007F0,
 0x0007E0, 0x0007C0, 0x0007C0, 0x007FE0, 0x01FFE0, 0x0FFFF8,
 0x3FFFEC, 0x03FFEC, 0x01FFE0, 0x00FFC0, 0x007FC0, 0x007F80,
 0x0039C0, 0x003180, 0x003180, 0x003180, 0x003180, 0x0039C0,
 0x0003FE, 0x0007FF, 0x00077F, 0x0007FF, 0x0007FF, 0x0007F0,
 0x0007E0, 0x0007C0, 0x0007C0, 0x007FE0, 0x01FFE0, 0x0FFFF8,
 0x3FFFEC, 0x03FFEC, 0x01FFE0, 0x00FFC0, 0x007FC0, 0x007F80,
 0x0039C0, 0x003180, 0x0031C0, 0x003000, 0x003000, 0x003800,
 0x0003FE, 0x0007FF, 0x00077F, 0x0007FF, 0x0007FF, 0x0007F0,
 0x0007E0, 0x0007C0, 0x0007C0, 0x007FE0, 0x01FFE0, 0x0FFFF8,
 0x3FFFEC, 0x03FFEC, 0x01FFE0, 0x00FFC0, 0x007FC0, 0x007F80,
 0x0039C0, 0x003180, 0x003980, 0x000180, 0x000180, 0x0001C0,
};
const uint16_t RN_CAC_SPR[] PROGMEM = {
 0x030, 0x078, 0x078, 0x078, 0x078, 0x07B, 0x37B,
 0x37B, 0x37B, 0x37B, 0x37B, 0x37F, 0x3FF, 0x1F8,
};
static void rnBlitRows(const uint32_t *rows, int nRows, int wBits, int x, int y, uint16_t col) {
 for (int r = 0; r < nRows; r++) {
 uint32_t v = pgm_read_dword(&rows[r]);
 int c = 0;
 while (c < wBits) {
 if ((v >> (wBits - 1 - c)) & 1) {
 int s = c; while (c < wBits && ((v >> (wBits - 1 - c)) & 1)) c++;
 gfx->fillRect(x + s, y + r, c - s, 1, col);
 } else { c++; }
 }
 }
}
#define RN_GROUND 138
#define RN_MAX 4
float rnY = 0, rnVy = 0, rnSpeed = 5; long rnDist = 0; int rnBest = 0; bool rnOver = false, rnAir = false; unsigned long rnOverAt = 0;
float rnOx[RN_MAX]; int rnOw[RN_MAX], rnOh[RN_MAX]; bool rnOn[RN_MAX]; int rnFrame = 0; float rnGround = 0;
void rnReset() {
 rnY = 0; rnVy = 0; rnSpeed = 5; rnDist = 0; rnOver = false; rnAir = false; rnFrame = 0; rnGround = 0;
 for (int i = 0; i < RN_MAX; i++) rnOn[i] = false;
 rnOn[0] = true; rnOx[0] = 420; rnOw[0] = 10; rnOh[0] = 20;
 mgLast = millis();
}
void rnDrawCactusStalk(int left, int hh) {
 if (hh < RN_CAC_TOP + 3) hh = RN_CAC_TOP + 3;
 int topY = RN_GROUND - hh;
 for (int r = 0; r < RN_CAC_TOP; r++) {
 uint16_t v = pgm_read_word(&RN_CAC_SPR[r]);
 int c = 0;
 while (c < RN_CAC_W) {
 if ((v >> (RN_CAC_W - 1 - c)) & 1) {
 int s = c; while (c < RN_CAC_W && ((v >> (RN_CAC_W - 1 - c)) & 1)) c++;
 gfx->fillRect(left + s, topY + r, c - s, 1, RN_SPRITE);
 } else { c++; }
 }
 }
 gfx->fillRect(left + 3, topY + RN_CAC_TOP, 4, hh - RN_CAC_TOP, RN_SPRITE);
}
void rnDrawCactus(int x, int w, int h) {
 int n = (w <= 10) ? 1 : (w <= 21) ? 2 : 3;
 for (int i = 0; i < n; i++) rnDrawCactusStalk(x + i * 11, h);
}
void rnDraw() {
 UiCanvasGuard _g;
 int skyBot = RN_GROUND - 4;
 int bands = 10;
 int bandH = max(1, skyBot / bands);
 for (int i = 0; i < bands; i++) {
 float t = (float)i / (bands - 1);
 uint16_t c = blendRGB565(RN_SKY_TOP, RN_SKY_BOT, t);
 int y = i * bandH;
 int h = (i == bands - 1) ? (skyBot - y) : bandH;
 gfx->fillRect(0, y, MG_W, h, c);
 }
 int sunX = MG_W - 40, sunY = 26;
 gfx->fillCircle(sunX, sunY, 18, blendRGB565(RN_SKY_TOP, RN_SUN, 0.4f));
 gfx->fillCircle(sunX, sunY, 12, RN_SUN);
 gfx->fillCircle(sunX - 3, sunY - 3, 4, RN_SUN_CORE);
 int cloudX = ((int)(300 - rnGround * 0.2f) % 380 + 380) % 380 - 30;
 gfx->fillRect(cloudX - 12, 45, 30, 5, RN_CLOUD_SHADE);
 gfx->fillCircle(cloudX - 8, 42, 6, RN_CLOUD);
 gfx->fillCircle(cloudX + 2, 40, 9, RN_CLOUD);
 gfx->fillCircle(cloudX + 12, 43, 6, RN_CLOUD);
 gfx->fillRect(cloudX - 12, 43, 30, 3, RN_CLOUD);
 gfx->fillRect(0, skyBot, MG_W, 3, RN_SAND_TOP);
 gfx->fillRect(0, skyBot + 3, MG_W, 5, RN_SAND_MID);
 gfx->fillRect(0, skyBot + 8, MG_W, MG_H - skyBot - 8, RN_SAND_BOT);
 for (int i = 0; i < 8; i++) { int gx = ((i * 47 - (int)rnGround) % 380 + 380) % 380 - 30; gfx->fillRect(gx, RN_GROUND + 6 + (i % 3) * 5, 8 + (i % 2) * 6, 2, blendRGB565(RN_SAND_BOT, COLOR_BLACK, 0.18f)); }
 char scoreBuf[16]; snprintf(scoreBuf, sizeof(scoreBuf), "%d", (int)(rnDist / 8));
 String scoreStr = String(tr("Score: ", "Điểm: ")) + scoreBuf;
 mgTxtC(scoreStr, MG_W - 5, 5, DATUM_TR, blendRGB565(RN_SKY_TOP, COLOR_BLACK, 0.35f), RN_SKY_TOP);
 mgTxtC(scoreStr, MG_W - 6, 4, DATUM_TR, MG_TXT, RN_SKY_TOP);
 mgTxtC(String(tr("Best: ", "Kỷ lục: ")) + String(rnBest), 6, 4, DATUM_TL, blendRGB565(RN_SKY_TOP, COLOR_BLACK, 0.3f), RN_SKY_TOP);
 for (int i = 0; i < RN_MAX; i++) if (rnOn[i]) rnDrawCactus((int)rnOx[i], rnOw[i], rnOh[i]);
 int dy = RN_GROUND - (RN_DINO_H - 1) - (int)rnY;
 int frame = rnAir ? 0 : (1 + ((rnFrame / 3) & 1));
 rnBlitRows(&RN_DINO_SPR[frame * RN_DINO_H], RN_DINO_H, RN_DINO_W, RN_DINO_X, dy, RN_SPRITE);
 if (rnOver) mgBanner(tr("Game Over!", "Thua rồi!"), tr("Tap to retry", "Chạm để chơi lại"));
}
void rnLoop(bool key) {
 if (rnOver) { if ((mgT.pressed || key) && millis() - rnOverAt > 700) { rnReset(); rnDraw(); } return; }
 static unsigned long rnJumpBufUntil = 0;
 if (mgT.pressed || key) rnJumpBufUntil = millis() + 220;
 if (!rnAir && millis() < rnJumpBufUntil) { rnVy = 7.3f; rnAir = true; rnJumpBufUntil = 0; }
 if (!mgTick(24)) return;
 if (rnAir) { rnY += rnVy; rnVy -= 0.64f; if (rnY <= 0) { rnY = 0; rnVy = 0; rnAir = false; } }
 rnSpeed = 5 + rnDist / 1400.0f; if (rnSpeed > 11) rnSpeed = 11;
 rnDist += (long)rnSpeed; rnGround += rnSpeed; rnFrame++;
 float lastX = -999;
 for (int i = 0; i < RN_MAX; i++) if (rnOn[i]) {
 rnOx[i] -= rnSpeed; if (rnOx[i] + rnOw[i] < -4) rnOn[i] = false;
 if (rnOx[i] > lastX) lastX = rnOx[i];
 }
 if (lastX < MG_W - (150 + random(120)) - rnSpeed * 8) {
 for (int i = 0; i < RN_MAX; i++) if (!rnOn[i]) {
 rnOn[i] = true; rnOx[i] = MG_W + 10; int k = random(3);
 rnOw[i] = 10 + k * 11; rnOh[i] = 19 + random(4);
 break;
 }
 }
 int dx = RN_DINO_X + 6, dw = 14, dTop = RN_GROUND - RN_DINO_H - (int)rnY + 3, dBot = RN_GROUND - (int)rnY - 2;
 for (int i = 0; i < RN_MAX; i++) if (rnOn[i]) {
 int ox = (int)rnOx[i] + 2, ow = rnOw[i] - 4, oTop = RN_GROUND - rnOh[i];
 if (dx < ox + ow && dx + dw > ox && dBot > oTop && dTop < RN_GROUND) {
 rnOver = true; rnOverAt = millis(); if ((int)(rnDist / 8) > rnBest) rnBest = (int)(rnDist / 8);
 }
 }
 rnDraw();
}
#define IV_C 8
#define IV_R 4
#define IV_PX 22
#define IV_PY 18
#define IV_SHIP_Y 154
static const uint8_t IV_SPR[2][2][8] = {
 { {0x18,0x3C,0x7E,0xDB,0xFF,0x24,0x5A,0xA5}, {0x18,0x3C,0x7E,0xDB,0xFF,0x5A,0x81,0x42} },
 { {0x3C,0x7E,0xFF,0x99,0xFF,0x42,0x24,0x42}, {0x3C,0x7E,0xFF,0x99,0xFF,0x24,0x42,0x24} } };
bool ivAlive[IV_R][IV_C]; int ivFx = 20, ivFy = 24, ivDir = 1, ivAnim = 0, ivScore = 0, ivLives = 3, ivWave = 1, ivBest = 0, ivShipX = 160, ivLeft = 0;
float ivBx[2], ivBy[2]; bool ivBon[2]; float ivEx[3], ivEy[3]; bool ivEon[3];
unsigned long ivStepAt = 0, ivFireAt = 0, ivHurtUntil = 0, ivOverAt = 0; bool ivOver = false;
void ivWaveInit() {
 for (int r = 0; r < IV_R; r++) for (int c = 0; c < IV_C; c++) ivAlive[r][c] = true;
 ivLeft = IV_R * IV_C; ivFx = 20; ivFy = 24; ivDir = 1;
 for (int i = 0; i < 2; i++) ivBon[i] = false;
 for (int i = 0; i < 3; i++) ivEon[i] = false;
 ivStepAt = millis() + 600;
}
void ivReset() { ivScore = 0; ivLives = 3; ivWave = 1; ivOver = false; ivShipX = 160; ivHurtUntil = 0; ivWaveInit(); mgLast = millis(); }
void mgSprite(const uint8_t *rows, int x, int y, int scale, uint16_t col) {
 for (int r = 0; r < 8; r++) {
 int c = 0;
 while (c < 8) {
 if ((rows[r] >> (7 - c)) & 1) {
 int s = c; while (c < 8 && ((rows[r] >> (7 - c)) & 1)) c++;
 gfx->fillRect(x + s * scale, y + r * scale, (c - s) * scale, scale, col);
 } else { c++; }
 }
 }
}
void ivDraw() {
 UiCanvasGuard _g;
 gfx->fillScreen(MG_BG);
 static const uint16_t rowCol[IV_R] = { MGC(240,90,90), MGC(250,170,60), MGC(90,220,120), MGC(90,170,255) };
 for (int r = 0; r < IV_R; r++) for (int c = 0; c < IV_C; c++) if (ivAlive[r][c])
 mgSprite(IV_SPR[r & 1][ivAnim & 1], ivFx + c * IV_PX, ivFy + r * IV_PY, 2, rowCol[r]);
 bool blink = millis() < ivHurtUntil && ((millis() / 100) & 1);
 if (!blink) {
 gfx->fillTriangle(ivShipX, IV_SHIP_Y - 6, ivShipX - 10, IV_SHIP_Y + 6, ivShipX + 10, IV_SHIP_Y + 6, MG_TXT);
 gfx->fillRoundRect(ivShipX - 12, IV_SHIP_Y + 6, 24, 4, 2, MGC(90, 220, 240));
 }
 for (int i = 0; i < 2; i++) if (ivBon[i]) gfx->fillRect((int)ivBx[i] - 1, (int)ivBy[i] - 4, 2, 8, MGC(255, 240, 120));
 for (int i = 0; i < 3; i++) if (ivEon[i]) gfx->fillRect((int)ivEx[i] - 1, (int)ivEy[i] - 3, 3, 7, MGC(255, 90, 90));
 mgTxt(String(tr("Score: ", "Điểm: ")) + String(ivScore), 6, 2, DATUM_TL);
 mgTxtC(String(tr("Lives: ", "Mạng: ")) + String(ivLives) + "  W" + String(ivWave), MG_W - 6, 2, DATUM_TR, MG_DIM, MG_BG);
 if (ivOver) mgBanner(tr("Game Over!", "Thua rồi!"), String(tr("Best ", "Kỷ lục ")) + String(ivBest) + " - " + tr("tap", "chạm"));
}
void ivLoop(bool key) {
 (void)key;
 unsigned long now = millis();
 if (ivOver) { if (mgT.pressed && now - ivOverAt > 700) { ivReset(); ivDraw(); } return; }
 if (mgT.down) {
 int d = mgT.x - ivShipX;
 ivShipX += (abs(d) <= 6) ? d : (d > 0 ? 6 : -6);
 ivShipX = mgClamp(ivShipX, 14, MG_W - 14);
 }
 if (!mgTick(25)) return;
 if (now >= ivStepAt) {
 int minC = IV_C, maxC = -1;
 for (int r = 0; r < IV_R; r++) for (int c = 0; c < IV_C; c++) if (ivAlive[r][c]) { if (c < minC) minC = c; if (c > maxC) maxC = c; }
 int left = ivFx + minC * IV_PX, right = ivFx + maxC * IV_PX + 16;
 if ((ivDir > 0 && right + 5 > MG_W - 4) || (ivDir < 0 && left - 5 < 4)) { ivDir = -ivDir; ivFy += 8; } else { ivFx += 5 * ivDir; }
 ivAnim++;
 ivStepAt = now + mgMax(40, 30 + ivLeft * 14 - (ivWave - 1) * 25);
 }
 if (now >= ivFireAt) {
 for (int i = 0; i < 2; i++) if (!ivBon[i]) { ivBon[i] = true; ivBx[i] = ivShipX; ivBy[i] = IV_SHIP_Y - 8; ivFireAt = now + 380; break; }
 }
 for (int i = 0; i < 2; i++) if (ivBon[i]) {
 ivBy[i] -= 7;
 if (ivBy[i] < 18) { ivBon[i] = false; continue; }
 for (int r = 0; r < IV_R && ivBon[i]; r++) for (int c = 0; c < IV_C; c++) if (ivAlive[r][c]) {
 int x = ivFx + c * IV_PX, y = ivFy + r * IV_PY;
 if (ivBx[i] >= x && ivBx[i] <= x + 16 && ivBy[i] >= y && ivBy[i] <= y + 16) {
 ivAlive[r][c] = false; ivLeft--; ivBon[i] = false; ivScore += 10 * (IV_R - r); break;
 }
 }
 }
 if (random(100) < 3 + ivWave) {
 for (int i = 0; i < 3; i++) if (!ivEon[i]) {
 int c = random(IV_C);
 for (int r = IV_R - 1; r >= 0; r--) if (ivAlive[r][c]) { ivEon[i] = true; ivEx[i] = ivFx + c * IV_PX + 8; ivEy[i] = ivFy + r * IV_PY + 16; break; }
 break;
 }
 }
 for (int i = 0; i < 3; i++) if (ivEon[i]) {
 ivEy[i] += 3.2f + 0.3f * ivWave;
 if (ivEy[i] > MG_H) { ivEon[i] = false; continue; }
 if (now >= ivHurtUntil && ivEy[i] >= IV_SHIP_Y - 6 && ivEy[i] <= IV_SHIP_Y + 8 && fabsf(ivEx[i] - ivShipX) <= 12) {
 ivEon[i] = false; ivLives--; ivHurtUntil = now + 1200;
 if (ivLives <= 0) { ivOver = true; ivOverAt = now; if (ivScore > ivBest) ivBest = ivScore; }
 }
 }
 for (int r = 0; r < IV_R; r++) for (int c = 0; c < IV_C; c++) if (ivAlive[r][c] && ivFy + r * IV_PY + 16 >= IV_SHIP_Y - 6) {
 ivLives = 0; ivOver = true; ivOverAt = now; if (ivScore > ivBest) ivBest = ivScore;
 }
 if (!ivOver && ivLeft == 0) { ivWave++; ivWaveInit(); }
 ivDraw();
}
void mgReset() {
 mgTouchReset();
 switch (miniId) {
 case MG_SNAKE: snReset(); break; case MG_TETRIS: teReset(); break; case MG_MINES: mnReset(); break;
 case MG_MEMORY: mmReset(); break; case MG_WHACK: wkReset(); break; case MG_SIMON: smReset(); break;
 case MG_BREAKOUT: brReset(); break; case MG_PONG: pgReset(); break; case MG_SUDOKU: sdReset(); break;
 case MG_C4: c4Reset(); break; case MG_OTHELLO: otReset(); break; case MG_RUNNER: rnReset(); break;
 case MG_CHESS: chReset(); break; case MG_XIANGQI: xqReset(); break;
 default: ivReset(); break;
 }
}
void drawMini() {
 switch (miniId) {
 case MG_SNAKE: snDraw(); break; case MG_TETRIS: teDraw(); break; case MG_MINES: mnDraw(); break;
 case MG_MEMORY: mmDraw(); break; case MG_WHACK: wkDraw(); break; case MG_SIMON: smDraw(); break;
 case MG_BREAKOUT: brDraw(); break; case MG_PONG: pgDraw(); break; case MG_SUDOKU: sdDraw(); break;
 case MG_C4: c4Draw(); break; case MG_OTHELLO: otDraw(); break; case MG_RUNNER: rnDraw(); break;
 case MG_CHESS: chDraw(); break; case MG_XIANGQI: xqDraw(); break;
 default: ivDraw(); break;
 }
}
void mgEnter(int id, int rx, int ry, int rw, int rh) {
 miniId = id;
 mgReset();
 appState = STATE_MINI;
 openScreenWithZoom(rx, ry, rw, rh, drawMini);
 mgLast = millis();
}
void mgExit() {
 int exitId = miniId;
 gamesMenuIndex = GAMES_OLD + miniId;
 int rx, ry, rw, rh;
 gamesMenuRowRect(gamesMenuIndex, rx, ry, rw, rh);
 appState = STATE_GAMES_MENU;
 closeScreenWithZoom(rx, ry, rw, rh, drawMini, drawGamesMenu);
 if (exitId == MG_CHESS) chReset(); else if (exitId == MG_XIANGQI) xqReset();
}
void loopMini() {
 if (evt_boot_double || evt_pin14_double) { evt_boot_double = false; evt_pin14_double = false; mgExit(); return; }
 if (evt_boot_single) { evt_boot_single = false; mgReset(); drawMini(); return; }
 bool key = false;
 if (evt_pin14_single) { evt_pin14_single = false; key = true; }
 mgTouchPoll();
 switch (miniId) {
 case MG_SNAKE: snLoop(key); break; case MG_TETRIS: teLoop(key); break; case MG_MINES: mnLoop(key); break;
 case MG_MEMORY: mmLoop(key); break; case MG_WHACK: wkLoop(key); break; case MG_SIMON: smLoop(key); break;
 case MG_BREAKOUT: brLoop(key); break; case MG_PONG: pgLoop(key); break; case MG_SUDOKU: sdLoop(key); break;
 case MG_C4: c4Loop(key); break; case MG_OTHELLO: otLoop(key); break; case MG_RUNNER: rnLoop(key); break;
 case MG_CHESS: chLoop(key); break; case MG_XIANGQI: xqLoop(key); break;
 default: ivLoop(key); break;
 }
 updateGameBackground();
}
String photoFitName(const String &name, int maxW) {
 int16_t x1, y1; uint16_t w, h;
 gfx->getTextBounds(name.c_str(), 0, 0, &x1, &y1, &w, &h);
 if ((int)w <= maxW) return name;
 int dot = name.lastIndexOf('.');
 String ext = (dot > 0 && (int)name.length() - dot <= 6) ? name.substring(dot) : String("");
 String base = ext.length() ? name.substring(0, dot) : name;
 while (base.length() > 1) {
 base.remove(utf8LastCharStart(base));
 String t = base + "~" + ext;
 gfx->getTextBounds(t.c_str(), 0, 0, &x1, &y1, &w, &h);
 if ((int)w <= maxW) return t;
 }
 return base + "~" + ext;
}
String photoShortName(const String &name) {
 if (name.length() <= 28) return name;
 uint32_t hsh = 2166136261u;
 for (size_t i = 0; i < name.length(); i++) { hsh ^= (uint8_t)name[i]; hsh *= 16777619u; }
 int dot = name.lastIndexOf('.');
 String ext = (dot > 0 && (int)name.length() - dot <= 6) ? name.substring(dot) : String(".jpg");
 String pre = "";
 for (int i = 0; i < (int)name.length() && pre.length() < 12; i++) {
 char c = name[i];
 if (isalnum((unsigned char)c) || c == '-') pre += c; else if (c == '_' || c == ' ') pre += '_';
 }
 char hx[9]; snprintf(hx, sizeof(hx), "%08x", (unsigned)hsh);
 return pre + "_" + String(hx) + ext;
}
#define PHOTO_COPY_ZONE_W 32
void copyPhotoToInternal(int idx);

#define PHOTO_INTERNAL_RIGHT_W 78
void deletePhotoFromInternal(int idx);




int lastDrawnPhotoIndex = -1;
int lastDrawnPhotoTop = -1;

extern bool gmPickingPhoto;
void drawGeminiPrompt();

#define PH_THUMB_DIR "/Photos/.thumbs"
#define PH_RAM_SLOTS 24
static int gThCols = 2, gThCell = 76, gThGap = 6, gThRowH = 82, gThTop0 = 22;
static int gThScroll = 0;
static uint16_t *gThPx[PH_RAM_SLOTS];
static int16_t gThIdx[PH_RAM_SLOTS];
static int gThNext = 0;
static uint8_t gThState[MAX_PHOTOS];
static uint8_t gPhRot[MAX_PHOTOS];
static uint16_t *gThTmp = nullptr;
static int gThTw = 0, gThTh = 0;
static void phGridReset() {
 gThDirty = false;
 for (int i = 0; i < MAX_PHOTOS; i++) { gThState[i] = 0; gPhRot[i] = 0xFF; }
 for (int s = 0; s < PH_RAM_SLOTS; s++) gThIdx[s] = -1;
 gThNext = 0;
}
static void phLayout() {
 int W = gfx->width();
 gThGap = 6;
 gThCols = max(2, W / 80);
 gThCell = (W - (gThCols + 1) * gThGap) / gThCols;
 gThRowH = gThCell + gThGap;
}
static String phKey(int i) { return String(photoIsInternal[i] ? "dev_" : "") + photoShortName(photoList[i]); }
static String phThPath(int i, const char *ext) { return String(PH_THUMB_DIR) + "/" + phKey(i) + ext; }
static uint8_t phRotGet(int i) {
 if (gThDirty) phGridReset();
 if (i < 0 || i >= MAX_PHOTOS) return 0;
 if (gPhRot[i] != 0xFF) return gPhRot[i];
 uint8_t r = 0;
 if (sdMounted) {
  FsFile f = sd.open(phThPath(i, ".r").c_str(), O_READ);
  if (f) { uint8_t b = 0; if (f.read(&b, 1) == 1 && b < 4) r = b; f.close(); }
 }
 gPhRot[i] = r;
 return r;
}
static void phThInvalidate(int i) {
 for (int s = 0; s < PH_RAM_SLOTS; s++) if (gThIdx[s] == i) gThIdx[s] = -1;
 if (i >= 0 && i < MAX_PHOTOS) gThState[i] = 0;
}
static void phRotSet(int i, uint8_t r) {
 if (gThDirty) phGridReset();
 r &= 3;
 gPhRot[i] = r;
 if (sdMounted) {
  if (!sd.exists(PH_THUMB_DIR)) sd.mkdir(PH_THUMB_DIR);
  String p = phThPath(i, ".r");
  if (r == 0) { sd.remove(p.c_str()); }
  else { FsFile f = sd.open(p.c_str(), O_WRITE | O_CREAT | O_TRUNC); if (f) { f.write(&r, 1); f.close(); } }
 }
 phThInvalidate(i);
}
static bool phThumbLoad(int idx, uint16_t *dst) {
 if (!sdMounted) return false;
 FsFile f = sd.open(phThPath(idx, ".t").c_str(), O_READ);
 if (!f) return false;
 uint8_t hd[8];
 bool ok = false;
 size_t bytes = (size_t)gThCell * gThCell * 2;
 if (f.read(hd, 8) == 8 && hd[0] == 'T' && hd[1] == 'H' && hd[2] == 'M' && hd[3] == '1' &&
     (int)(hd[4] | (hd[5] << 8)) == gThCell && hd[6] == phRotGet(idx)) {
  ok = ((size_t)f.read(dst, bytes) == bytes);
 }
 f.close();
 return ok;
}
static uint16_t *phSlotGet(int idx) {
 for (int s = 0; s < PH_RAM_SLOTS; s++) if (gThIdx[s] == idx && gThPx[s]) return gThPx[s];
 int s = gThNext; gThNext = (gThNext + 1) % PH_RAM_SLOTS;
 if (!gThPx[s]) gThPx[s] = (uint16_t *)allocBuffer((size_t)gThCell * gThCell * 2);
 if (!gThPx[s]) return nullptr;
 gThIdx[s] = -1;
 if (phThumbLoad(idx, gThPx[s])) { gThIdx[s] = idx; return gThPx[s]; }
 return nullptr;
}
static uint8_t *phReadFile(int idx, uint32_t &fsize, uint32_t cap) {
 uint8_t *buf = nullptr;
 fsize = 0;
 if (photoIsInternal[idx]) {
  String path = String(INTERNAL_PHOTO_DIR) + "/" + photoList[idx];
  fsize = lfsFileSize(path.c_str());
  if (fsize == 0 || fsize > cap) return nullptr;
  buf = allocBuffer(fsize);
  if (!buf) return nullptr;
  if (!lfsReadFileInto(path.c_str(), buf, fsize)) { free(buf); return nullptr; }
 } else {
  String path = String(PHOTO_DIR) + "/" + photoList[idx];
  FsFile f = sd.open(path.c_str(), O_READ);
  if (!f) return nullptr;
  fsize = f.fileSize();
  if (fsize == 0 || fsize > cap) { f.close(); return nullptr; }
  buf = allocBuffer(fsize);
  if (!buf) { f.close(); return nullptr; }
  int rd = f.read(buf, fsize);
  f.close();
  if (rd < 0 || (uint32_t)rd != fsize) { free(buf); return nullptr; }
 }
 return buf;
}
static bool thCb(int16_t x, int16_t y, uint16_t w, uint16_t h, uint16_t *bm) {
 if (!gThTmp) return false;
 for (int r = 0; r < h; r++) {
  int yy = y + r;
  if (yy < 0 || yy >= gThTh) continue;
  int x0 = x < 0 ? -x : 0;
  int x1 = (x + w > gThTw) ? (gThTw - x) : w;
  if (x1 <= x0) continue;
  memcpy(gThTmp + (size_t)yy * gThTw + x + x0, bm + (size_t)r * w + x0, (size_t)(x1 - x0) * sizeof(uint16_t));
 }
 return true;
}
static bool phIsJpegName(const String &n) {
 String l = n; l.toLowerCase();
 return l.endsWith(".jpg") || l.endsWith(".jpeg") || l.endsWith(".jpe") || l.endsWith(".jfif");
}
static bool phThumbMake(int idx) {
 if (!sdMounted || !phIsJpegName(photoList[idx])) return false;
 uint32_t fs = 0;
 uint8_t *buf = phReadFile(idx, fs, 6UL * 1024 * 1024);
 if (!buf) return false;
 bool ok = false;
 uint16_t jw = 0, jh = 0;
 if (fs > 3 && buf[0] == 0xFF && buf[1] == 0xD8 && TJpgDec.getJpgSize(&jw, &jh, buf, fs) == JDR_OK && jw > 0 && jh > 0) {
  const int dim = gThCell;
  int sc = 1;
  while (sc < 8 && (int)min((int)jw, (int)jh) / (sc * 2) >= dim) sc *= 2;
  gThTw = (jw + sc - 1) / sc; gThTh = (jh + sc - 1) / sc;
  gThTmp = (uint16_t *)allocBuffer((size_t)gThTw * gThTh * 2);
  if (gThTmp) {
   memset(gThTmp, 0, (size_t)gThTw * gThTh * 2);
   TJpgDec.setCallback(thCb);
   TJpgDec.setJpgScale(sc);
   JRESULT jr = TJpgDec.drawJpg(0, 0, buf, fs);
   TJpgDec.setJpgScale(1);
   TJpgDec.setCallback(tftOutputCallback);
   if (jr == JDR_OK) {
    uint16_t *out = (uint16_t *)allocBuffer((size_t)dim * dim * 2);
    if (out) {
     const int side = min(gThTw, gThTh);
     const int cx0 = (gThTw - side) / 2, cy0 = (gThTh - side) / 2;
     const uint8_t rot = phRotGet(idx);
     for (int oy = 0; oy < dim; oy++) {
      int v = (int)((int64_t)oy * side / dim);
      for (int ox = 0; ox < dim; ox++) {
       int u = (int)((int64_t)ox * side / dim);
       int qx, qy;
       switch (rot) {
        case 1: qx = v; qy = side - 1 - u; break;
        case 2: qx = side - 1 - u; qy = side - 1 - v; break;
        case 3: qx = side - 1 - v; qy = u; break;
        default: qx = u; qy = v; break;
       }
       out[(size_t)oy * dim + ox] = gThTmp[(size_t)(cy0 + qy) * gThTw + cx0 + qx];
      }
     }
     if (!sd.exists(PH_THUMB_DIR)) sd.mkdir(PH_THUMB_DIR);
     FsFile f = sd.open(phThPath(idx, ".t").c_str(), O_WRITE | O_CREAT | O_TRUNC);
     if (f) {
      uint8_t hd[8] = { 'T', 'H', 'M', '1', (uint8_t)(dim & 255), (uint8_t)(dim >> 8), rot, 0 };
      size_t bytes = (size_t)dim * dim * 2;
      ok = (f.write(hd, 8) == 8) && ((size_t)f.write((const uint8_t *)out, bytes) == bytes);
      f.close();
     }
     free(out);
    }
   }
   free(gThTmp); gThTmp = nullptr;
  }
 }
 free(buf);
 return ok;
}
static int phAreaBottom() { return gfx->height() - GESTURE_BAR_ZONE_H; }
static int phMaxScroll() {
 int rows = (photoCount + gThCols - 1) / gThCols;
 int content = rows * gThRowH + gThGap;
 int area = phAreaBottom() - gThTop0;
 return content > area ? content - area : 0;
}
static void phEnsureVisible() {
 if (photoCount == 0) { gThScroll = 0; return; }
 int row = photoIndex / gThCols;
 int top = row * gThRowH, bot = top + gThRowH + gThGap;
 int area = phAreaBottom() - gThTop0;
 if (top < gThScroll) gThScroll = top;
 if (bot > gThScroll + area) gThScroll = bot - area;
 int ms = phMaxScroll();
 if (gThScroll > ms) gThScroll = ms;
 if (gThScroll < 0) gThScroll = 0;
}
static void phFillClip(int x, int y, int w, int h, uint16_t c) {
 int t = gThTop0, b = phAreaBottom();
 if (y < t) { h -= (t - y); y = t; }
 if (y + h > b) h = b - y;
 if (h > 0 && w > 0) gfx->fillRect(x, y, w, h, c);
}
static void phDrawCell(int i, int x, int y) {
 const int cell = gThCell, t = gThTop0, b = phAreaBottom();
 if (y + cell <= t || y >= b) return;
 uint16_t *px = nullptr;
 if (gThState[i] == 0 || gThState[i] == 1) {
  px = phSlotGet(i);
  gThState[i] = px ? 1 : 2;
 }
 if (px) {
  for (int r = 0; r < cell; r++) {
   int yy = y + r;
   if (yy < t || yy >= b) continue;
   gfx->draw16bitRGBBitmap(x, yy, px + (size_t)r * cell, cell, 1);
  }
 } else {
  phFillClip(x, y, cell, cell, IOS_GRAY);
  if (y >= t && y + cell <= b) {
   String n = photoList[i];
   int dot = n.lastIndexOf('.');
   String lb = (gThState[i] == 3 && dot >= 0) ? n.substring(dot + 1) : String("...");
   lb.toUpperCase();
   if (lb.length() > 5) lb = lb.substring(0, 5);
   gfxSetTextColor(COLOR_WHITE, IOS_GRAY);
   gfxDrawAligned(lb, x + cell / 2, y + cell / 2, DATUM_MC);
  }
 }
 if (i == photoIndex) {
  for (int k = 0; k < 2; k++) {
   phFillClip(x - 1 - k, y - 1 - k, cell + 2 + 2 * k, 1, colorAccent);
   phFillClip(x - 1 - k, y + cell + k, cell + 2 + 2 * k, 1, colorAccent);
   phFillClip(x - 1 - k, y - 1 - k, 1, cell + 2 + 2 * k, colorAccent);
   phFillClip(x + cell + k, y - 1 - k, 1, cell + 2 + 2 * k, colorAccent);
  }
 }
}
static void phGridPaint() {
 int firstRow = max(0, (gThScroll - gThGap) / gThRowH);
 int lastRow = (gThScroll + phAreaBottom() - gThTop0) / gThRowH + 1;
 for (int row = firstRow; row <= lastRow; row++) {
  for (int c = 0; c < gThCols; c++) {
   int i = row * gThCols + c;
   if (i >= photoCount) break;
   phDrawCell(i, gThGap + c * (gThCell + gThGap), gThTop0 + gThGap + row * gThRowH - gThScroll);
  }
 }
}
void drawPhotoMenu() {
 if (gThDirty) phGridReset();
 phLayout();
 phEnsureVisible();
 UiCanvasGuard _uiGuard;
 glFillScreen();
 drawHeader();
 gfxSetTextColor(colorFG, colorBG);
 if (photoCount == 0) {
  gfxDrawAligned(tr("No photos in /Photos", "Không có ảnh trong /Photos"), 8, 40, DATUM_TL);
  if (!photoScanDirOpened) gfxDrawAligned(tr("Cannot open /Photos (SD?)", "Không mở được /Photos (thẻ SD?)"), 8, 62, DATUM_TL);
  else gfxDrawAligned(tr("Folder is empty", "Thư mục trống"), 8, 62, DATUM_TL);
  return;
 }
 phGridPaint();
}
static void phGridRedrawArea() {
 UiCanvasGuard _uiGuard;
 phFillClip(0, gThTop0, gfx->width(), phAreaBottom() - gThTop0, colorBG);
 phGridPaint();
}
static int phHit(int16_t sx, int16_t sy) {
 if (sy < gThTop0 || sy >= phAreaBottom()) return -1;
 int rel = sy - gThTop0 - gThGap + gThScroll;
 if (rel < 0) return -1;
 int row = rel / gThRowH, ry = rel % gThRowH;
 if (ry >= gThCell) return -1;
 int cx = sx - gThGap;
 if (cx < 0) return -1;
 int col = cx / (gThCell + gThGap), rx = cx % (gThCell + gThGap);
 if (col >= gThCols || rx >= gThCell) return -1;
 int i = row * gThCols + col;
 return (i < photoCount) ? i : -1;
}
static bool phGenTick() {
 if (photoCount == 0) return false;
 int firstRow = max(0, (gThScroll - gThGap) / gThRowH);
 int lastRow = (gThScroll + phAreaBottom() - gThTop0) / gThRowH + 1;
 for (int pass = 0; pass < 2; pass++) {
  int a = pass == 0 ? firstRow * gThCols : 0;
  int b = pass == 0 ? min(photoCount, (lastRow + 1) * gThCols) : photoCount;
  for (int i = a; i < b; i++) {
   if (gThState[i] != 2) continue;
   if (!phIsJpegName(photoList[i])) { gThState[i] = 3; continue; }
   bool ok = phThumbMake(i);
   gThState[i] = ok ? 0 : 3;
   return true;
  }
 }
 return false;
}
extern bool gmPickingPhoto;
void drawGeminiPrompt();
void loopPhotoMenu() {
 static bool pressed = false, drag = false;
 static int16_t x0 = 0, y0 = 0, x1 = 0, y1 = 0;
 static int scroll0 = 0;
 static unsigned long t0 = 0, lastPaint = 0;
 if (gThDirty) { phGridReset(); }
 phLayout();
 bool redraw = false;
 int16_t nx, ny, sx, sy;
 bool down = touchReadDebounced(nx, ny);
 if (down) {
  touchToScreen(nx, ny, sx, sy);
  if (!pressed) { pressed = true; drag = false; x0 = sx; y0 = sy; t0 = millis(); scroll0 = gThScroll; }
  x1 = sx; y1 = sy;
  if (y0 < phAreaBottom() && (drag || abs(y1 - y0) > 8)) {
   drag = true;
   int ns = scroll0 - (y1 - y0);
   int ms = phMaxScroll();
   if (ns < 0) ns = 0;
   if (ns > ms) ns = ms;
   if (ns != gThScroll && millis() - lastPaint > 30) { gThScroll = ns; lastPaint = millis(); phGridRedrawArea(); }
  }
 } else if (pressed) {
  pressed = false;
  if (!drag && y0 < phAreaBottom() && abs(x1 - x0) < 12 && abs(y1 - y0) < 12 && millis() - t0 < 700) {
   int hit = phHit(x0, y0);
   if (hit >= 0) {
    photoIndex = hit;
    if (gmPickingPhoto) {
     gmPickingPhoto = false; appState = STATE_GEMINI; gmSetAttachFromPhoto(photoIndex); drawGeminiPrompt(); return;
    }
    runPhotoViewer(photoIndex);
    lastActivity = millis();
    drawPhotoMenu();
    return;
   }
  }
 }
 if (evt_pin14_single) { evt_pin14_single = false; if (photoCount > 0) { photoIndex = (photoIndex + 1) % photoCount; redraw = true; } }
 if (evt_boot_single) { evt_boot_single = false; if (photoCount > 0) { photoIndex = (photoIndex - 1 + photoCount) % photoCount; redraw = true; } }
 if (evt_pin14_double) {
  evt_pin14_double = false;
  if (photoCount > 0) {
   if (gmPickingPhoto) { gmPickingPhoto = false; appState = STATE_GEMINI; gmSetAttachFromPhoto(photoIndex); drawGeminiPrompt(); return; }
   runPhotoViewer(photoIndex);
   lastActivity = millis();
   drawPhotoMenu();
   return;
  }
 }
 if (evt_boot_double) {
  evt_boot_double = false;
  if (gmPickingPhoto) { gmPickingPhoto = false; appState = STATE_GEMINI; drawGeminiPrompt(); return; }
  int zx, zy, zw, zh;
  menuGridCell(0, menuFixedRows(), zx, zy, zw, zh);
  menuIndex = 0; menuTop = 0;
  appState = STATE_MENU;
  closeScreenWithZoom(zx, zy, zw, zh, drawPhotoMenu, drawMenu);
  return;
 }
 if (redraw) { phEnsureVisible(); phGridRedrawArea(); }
 if (!pressed && !redraw && phGenTick()) phGridRedrawArea();
 updateClockAndWeather();
}
String fitFileName(const String &name, int maxW) {
 int16_t x1, y1; uint16_t w, h;
 gfx->getTextBounds(name.c_str(), 0, 0, &x1, &y1, &w, &h);
 if ((int)w <= maxW) return name;
 int dot = name.lastIndexOf('.');
 String ext = (dot > 0) ? name.substring(dot) : String("");
 String stem = (dot > 0) ? name.substring(0, dot) : name;
 gfx->getTextBounds(ext.c_str(), 0, 0, &x1, &y1, &w, &h);
 return truncateToWidth(stem, maxW - (int)w) + ext;
}
static bool gVidCompact = false;
#define VID_ROW_H (gVidCompact ? 30 : 44)
#define VT_N 12
#define VT_MAXW 56
#define VT_MAXH 40
static bool gVidShuffle = false;
static bool vcIdleBuild();
static uint32_t vcHash(const String &n) { uint32_t h = 2166136261u; for (size_t i = 0; i < n.length(); i++) { h ^= (uint8_t)n[i]; h *= 16777619u; } return h; }
static String vcPath(const String &name, const char *ext) { char b[24]; snprintf(b, sizeof(b), "/.cache/%08x.%s", (unsigned)vcHash(name), ext); return String(VIDEO_DIR) + b; }
static bool vcReadPos(const String &name, VcPos &p) { FsFile f = sd.open(vcPath(name, "pos").c_str(), O_READ); if (!f) return false; bool ok = f.read(&p, sizeof(p)) == (int)sizeof(p); f.close(); return ok; }
static VtEnt gVt[VT_N];
static uint8_t gVtNext = 0;
static uint16_t *gVtDst; static int gVtW, gVtH;
static bool vtCb(int16_t x, int16_t y, uint16_t w, uint16_t h, uint16_t *bmp) {
 for (int r = 0; r < h; r++) { int yy = y + r; if (yy < 0 || yy >= gVtH) continue;
  for (int c = 0; c < w; c++) { int xx = x + c; if (xx < 0 || xx >= gVtW) continue; gVtDst[yy * gVtW + xx] = bmp[r * w + c]; } }
 return true;
}
static void vcInvalidate(const String &name) { for (int i = 0; i < VT_N; i++) if (gVt[i].used && gVt[i].name == name) gVt[i].used = false; }
static VtEnt *vtGet(const String &name) {
 for (int i = 0; i < VT_N; i++) if (gVt[i].used && gVt[i].name == name) return &gVt[i];
 VtEnt &e = gVt[gVtNext]; gVtNext = (gVtNext + 1) % VT_N;
 e.used = true; e.name = name; e.w = e.h = 0; e.hasPos = vcReadPos(name, e.pos);
 {
  FsFile tf = sd.open(vcPath(name, "th").c_str(), O_READ);
  if (tf) {
   uint32_t hd[2];
   if (tf.read(hd, 8) == 8 && hd[0] == 0x31485448UL) {
    int tw = (int)(hd[1] & 0xFFFF), thh = (int)(hd[1] >> 16);
    if (tw > 0 && thh > 0 && tw <= VT_MAXW && thh <= VT_MAXH) {
     if (!e.px) e.px = (uint16_t *)allocBuffer(VT_MAXW * VT_MAXH * 2);
     if (e.px && tf.read(e.px, (size_t)tw * thh * 2) == (int)((size_t)tw * thh * 2)) { e.w = tw; e.h = thh; }
    }
   }
   tf.close();
   if (e.w) return &e;
  }
 }
 FsFile f = sd.open(vcPath(name, "jpg").c_str(), O_READ);
 if (f) {
  uint32_t n = f.fileSize();
  if (n > 8 && n <= 65536) {
   uint8_t *b = allocBuffer(n);
   if (b) {
    if (f.read(b, n) == (int)n) {
     uint16_t jw = 0, jh = 0; TJpgDec.getJpgSize(&jw, &jh, b, n);
     uint8_t sc = 1; while (sc < 8 && (jw / sc > VT_MAXW || jh / sc > VT_MAXH)) sc *= 2;
     int tw = (jw + sc - 1) / sc, th = (jh + sc - 1) / sc;
     if (jw && jh && tw <= VT_MAXW && th <= VT_MAXH) {
      if (!e.px) e.px = (uint16_t *)allocBuffer(VT_MAXW * VT_MAXH * 2);
      if (e.px) {
       gVtDst = e.px; gVtW = tw; gVtH = th;
       TJpgDec.setJpgScale(sc); TJpgDec.setCallback(vtCb);
       TJpgDec.drawJpg(0, 0, b, n);
       TJpgDec.setCallback(tftOutputCallback); TJpgDec.setJpgScale(1);
       e.w = tw; e.h = th;
      }
     }
    }
    free(b);
   }
  }
  f.close();
 }
 return &e;
}
static void vcThumbDraw(const String &name, int x, int y, int bw, int bh, uint16_t bg) {
 VtEnt *e = vtGet(name);
 if (e->w && e->px) {
  gfx->fillRect(x, y, bw, bh, COLOR_BLACK);
  if (e->w <= bw && e->h <= bh) {
   gfx->draw16bitRGBBitmap(x + (bw - e->w) / 2, y + (bh - e->h) / 2, e->px, e->w, e->h);
  } else {
   static uint16_t sc[VT_MAXW * VT_MAXH];
   int dw = bw, dh = e->h * bw / e->w;
   if (dh > bh) { dh = bh; dw = e->w * bh / e->h; }
   if (dw < 1) dw = 1;
   if (dh < 1) dh = 1;
   if (dw * dh <= VT_MAXW * VT_MAXH) {
    for (int j = 0; j < dh; j++) { int sy = j * e->h / dh; for (int i2 = 0; i2 < dw; i2++) sc[j * dw + i2] = e->px[sy * e->w + i2 * e->w / dw]; }
    gfx->draw16bitRGBBitmap(x + (bw - dw) / 2, y + (bh - dh) / 2, sc, dw, dh);
   }
  }
 } else {
  fillRoundRectAA(x, y, bw, bh, 5, 0x2104, bg);
  gfx->fillTriangle(x + bw / 2 - 5, y + bh / 2 - 7, x + bw / 2 - 5, y + bh / 2 + 7, x + bw / 2 + 7, y + bh / 2, COLOR_GRAY);
 }
}
void drawVideoRowBody(int i, int y, int rowH) {
 const bool sel = (i == videoIndex);
 const uint16_t bg = sel ? iosSelTint() : colorBG;
 const bool cp = gVidCompact;
 const int thH = cp ? rowH - 6 : 38, thW = cp ? (thH * 54 / 38) : 54;
 vcThumbDraw(fileList[i], 8, y + (rowH - thH) / 2, thW, thH, bg);
 const int tx = cp ? (8 + thW + 6) : 70;
 const uint8_t *oldFont = gfxCurrentFont();
 if (cp) gfxSetFont(u8g2_font_6x10_tf);
 gfxSetTextColor(colorFG, bg);
 gfxDrawAligned(fitFileName(fileList[i], gfx->width() - tx - 8), tx, y + (cp ? 3 : 4), DATUM_TL);
 VtEnt *e = vtGet(fileList[i]);
 if (e->hasPos && e->pos.total > 0) {
  char mb[40];
  unsigned ts = (unsigned)((uint64_t)e->pos.total * e->pos.usec / 1000000ULL);
  unsigned ps = (unsigned)((uint64_t)e->pos.frame * e->pos.usec / 1000000ULL);
  if (e->pos.frame > 0) snprintf(mb, sizeof(mb), "%u:%02u / %u:%02u", ps / 60, ps % 60, ts / 60, ts % 60);
  else snprintf(mb, sizeof(mb), "%u:%02u", ts / 60, ts % 60);
  gfxSetTextColor(COLOR_GRAY, bg);
  gfxDrawAligned(mb, tx, y + (cp ? 15 : 21), DATUM_TL);
  if (e->pos.frame > 0) {
   int bw = gfx->width() - tx - 12;
   gfx->fillRect(tx, y + rowH - 5, bw, 3, 0x4208);
   gfx->fillRect(tx, y + rowH - 5, (int)((uint64_t)bw * e->pos.frame / e->pos.total), 3, COLOR_WHITE);
  }
 }
 if (cp && oldFont) gfxSetFont(oldFont);
}
void drawVideoRow(int i, int row, int startY, int rowH) {
 int y = startY + row * rowH;
 if (i == videoIndex) {
 glFillBg(0, y, gfx->width(), rowH);
 fillRoundRectAA(2, y + 1, gfx->width() - 4, rowH - 2, 8, iosSelTint(), colorBG);
 gfxSetTextColor(colorFG, iosSelTint());
 } else {
 glFillBg(0, y, gfx->width(), rowH);
 gfxSetTextColor(colorFG, colorBG);
 }
 drawVideoRowBody(i, y, rowH);
 if (i == videoIndex) drawFocusRing(2, y + 1, gfx->width() - 4, rowH - 2, 8, 0);
}
int lastDrawnVideoIndex = -1;
int lastDrawnVideoTop = -1;
void drawVideoMenu() {
 UiCanvasGuard _uiGuard;
 { static bool vfInit = false; if (!vfInit) { vfInit = true; gVidCompact = prefs.getInt("vidfs", 0) != 0; } }
 glFillScreen();
 drawHeader();
 gfxSetTextColor(colorFG, colorBG);
 if (fileCount == 0) {
 gfxDrawAligned(tr("No videos in /videos", "Không có video trong /videos"), 8, 40, DATUM_TL);
 }
 int rowH = VID_ROW_H;
 int startY = 22;
 int maxVisible = (gfx->height() - startY - GESTURE_BAR_ZONE_H) / rowH;
 if (videoIndex < videoTop) videoTop = videoIndex;
 if (videoIndex >= videoTop + maxVisible) videoTop = videoIndex - maxVisible + 1;
 if (videoTop < 0) videoTop = 0;
 if (videoTop > fileCount - maxVisible) videoTop = max(0, fileCount - maxVisible);
 for (int row = 0; row < maxVisible && (videoTop + row) < fileCount; row++) {
 drawVideoRow(videoTop + row, row, startY, rowH);
 }
 lastDrawnVideoIndex = videoIndex;
 lastDrawnVideoTop = videoTop;
}
void drawVideoRowsOnly(int rowH, int startY, int maxVisible) {
 CanvasRectPush _rp(0, startY, gfx->width(), maxVisible * rowH);
 gfx->startWrite();
 for (int row = 0; row < maxVisible && (videoTop + row) < fileCount; row++) {
 drawVideoRow(videoTop + row, row, startY, rowH);
 }
 gfx->endWrite();
 lastDrawnVideoIndex = videoIndex;
 lastDrawnVideoTop = videoTop;
}
void drawVideoRowsSmooth(int rowH, int startY, int maxVisible, int offsetPx) {
 CanvasRectPush _rp(0, startY, gfx->width(), maxVisible * rowH);
 gfx->startWrite();
 int listTop = startY;
 int listBottom = startY + maxVisible * rowH;
 glFillBg(0, listTop, gfx->width(), listBottom - listTop);
 freeScrollFlicker(_rp);
 for (int row = -1; row <= maxVisible; row++) {
 int i = videoTop + row;
 if (i < 0 || i >= fileCount) continue;
 int y = startY + row * rowH - offsetPx;
 int rowBottom = y + rowH;
 int drawY = max(y, listTop);
 int drawBottom = min(rowBottom, listBottom);
 if (drawBottom <= drawY) continue;
 bool selected = (i == videoIndex);
 glFillBg(0, drawY, gfx->width(), drawBottom - drawY);
 if (y >= listTop && rowBottom <= listBottom) {
 if (selected) {
 fillRoundRectAA(2, y + 1, gfx->width() - 4, rowH - 2, 8, iosSelTint(), colorBG);
 gfxSetTextColor(colorFG, iosSelTint());
 } else {
 gfxSetTextColor(colorFG, colorBG);
 }
 drawVideoRowBody(i, y, rowH);
 if (selected) drawFocusRing(2, y + 1, gfx->width() - 4, rowH - 2, 8, 0);
 }
 }
 gfx->endWrite();
}
void updateVideoSelection() {
 if (lastDrawnVideoIndex < 0) { drawVideoMenu(); return; }
 int rowH = VID_ROW_H;
 int startY = 22;
 int maxVisible = (gfx->height() - startY - GESTURE_BAR_ZONE_H) / rowH;
 if (videoIndex < videoTop) videoTop = videoIndex;
 if (videoIndex >= videoTop + maxVisible) videoTop = videoIndex - maxVisible + 1;
 if (videoTop < 0) videoTop = 0;
 if (videoTop > fileCount - maxVisible) videoTop = max(0, fileCount - maxVisible);
 if (videoTop != lastDrawnVideoTop) { drawVideoRowsOnly(rowH, startY, maxVisible); return; }
 CanvasRectPush _rp(0, startY, gfx->width(), maxVisible * rowH);
 gfx->startWrite();
 int oldRow = lastDrawnVideoIndex - videoTop;
 if (oldRow >= 0 && oldRow < maxVisible) drawVideoRow(lastDrawnVideoIndex, oldRow, startY, rowH);
 int newRow = videoIndex - videoTop;
 if (newRow >= 0 && newRow < maxVisible) drawVideoRow(videoIndex, newRow, startY, rowH);
 gfx->endWrite();
 lastDrawnVideoIndex = videoIndex;
 lastDrawnVideoTop = videoTop;
}
void loopVideoMenu() {
 bool redraw = false;
 {
  static unsigned long vcT = 0;
  if (!listTouch.active && fileCount > 0 && (long)(millis() - vcT) > 0) {
   vcT = millis() + 300;
   if (vcIdleBuild()) {
    const int rH = VID_ROW_H, sY = 22;
    drawVideoRowsOnly(rH, sY, (gfx->height() - sY - GESTURE_BAR_ZONE_H) / rH);
   }
  }
 }
 {
 int rowH = VID_ROW_H, startY = 22;
 int maxVisible = (gfx->height() - startY - GESTURE_BAR_ZONE_H) / rowH;
 int offsetPx = 0;
 static int lastSmoothOffsetPx = 0;
 if (listTouchGesture(videoIndex, videoTop, fileCount, rowH, startY, maxVisible, &offsetPx)) {
 if (offsetPx != 0 || listTouch.dragging) {
 drawVideoRowsSmooth(rowH, startY, maxVisible, offsetPx);
 lastSmoothOffsetPx = offsetPx;
 } else {
 redraw = true;
 }
 }
 if (!listTouch.active && (lastDrawnVideoTop != videoTop || lastSmoothOffsetPx != 0)) {
 drawVideoRowsOnly(rowH, startY, maxVisible);
 lastSmoothOffsetPx = 0;
 }
 }
 if (evt_pin14_long) {
 evt_pin14_long = false;
 gVidCompact = !gVidCompact;
 prefs.putInt("vidfs", gVidCompact ? 1 : 0);
 lastDrawnVideoIndex = -1;
 drawVideoMenu();
 return;
 }
 if (evt_pin14_single) {
 evt_pin14_single = false;
 if (fileCount > 0) { videoIndex = (videoIndex + 1) % fileCount; redraw = true; }
 }
 if (evt_boot_single) {
 evt_boot_single = false;
 if (fileCount > 0) { videoIndex = (videoIndex - 1 + fileCount) % fileCount; redraw = true; }
 }
 if (evt_pin14_double) {
 evt_pin14_double = false;
 if (fileCount > 0) {
 uint32_t resumeAt = (vidSessionValid && vidSessionPath == fileList[videoIndex]) ? vidSessionFrame : 0;
 startPlayback(fileList[videoIndex], resumeAt);
 lastActivity = millis();
 return;
 }
 }
 if (evt_boot_double) {
 evt_boot_double = false;
 int zx, zy, zw, zh;
 menuGridCell(rowVideos(), menuFixedRows(), zx, zy, zw, zh);
 menuIndex = 0; menuTop = 0;
 appState = STATE_MENU;
 closeScreenWithZoom(zx, zy, zw, zh, drawVideoMenu, drawMenu);
 return;
 }
 if (redraw) updateVideoSelection();
 updateClockAndWeather();
}
bool drawJpegFromMemory(const uint8_t *data, uint32_t len) {
 if (!data || len == 0) return false;
 uint16_t jw = 0, jh = 0;
 TJpgDec.getJpgSize(&jw, &jh, data, len);
 if (jw == 0 || jh == 0) return false;
 uint8_t scale = 1;
 while (scale < 8 && (jw / scale > gfx->width() || jh / scale > gfx->height())) scale *= 2;
 TJpgDec.setJpgScale(scale);
 int16_t dispW = jw / scale, dispH = jh / scale;
 int16_t ox = (gfx->width() - dispW) / 2; if (ox < 0) ox = 0;
 int16_t oy = (gfx->height() - dispH) / 2; if (oy < 0) oy = 0;
 if (dispW < gfx->width() || dispH < gfx->height()) gfx->fillScreen(COLOR_BLACK);
 bool ok = TJpgDec.drawJpg(ox, oy, data, len);
 TJpgDec.setJpgScale(1);
 return ok;
}
bool bufferOutputCallback(int16_t x, int16_t y, uint16_t w, uint16_t h, uint16_t *bitmap) {
 if (!jpegBufferTarget) return true;
 int16_t W = gfx->width(), H = gfx->height();
 int16_t x1 = x + (int16_t)w, y1 = y + (int16_t)h;
 int16_t cx0 = max((int16_t)0, x), cy0 = max((int16_t)0, y);
 int16_t cx1 = min(W, x1), cy1 = min(H, y1);
 for (int16_t row = cy0; row < cy1; row++) {
 const uint16_t *src = bitmap + (size_t)(row - y) * w + (size_t)(cx0 - x);
 memcpy(jpegBufferTarget + (size_t)row * W + cx0, src, (size_t)(cx1 - cx0) * sizeof(uint16_t));
 }
 return true;
}
bool decodeJpegToBuffer(const uint8_t *data, uint32_t len, uint16_t *destBuf) {
 if (!data || len == 0 || !destBuf) return false;
 memset(destBuf, 0, (size_t)gfx->width() * gfx->height() * sizeof(uint16_t));
 uint16_t jw = 0, jh = 0;
 TJpgDec.getJpgSize(&jw, &jh, data, len);
 uint8_t scale = 1;
 while (scale < 8 && (jw / scale > gfx->width() || jh / scale > gfx->height())) scale *= 2;
 TJpgDec.setJpgScale(scale);
 int16_t dispW = jw / scale, dispH = jh / scale;
 int16_t ox = (gfx->width() - dispW) / 2; if (ox < 0) ox = 0;
 int16_t oy = (gfx->height() - dispH) / 2; if (oy < 0) oy = 0;
 jpegBufferTarget = destBuf;
 TJpgDec.setCallback(bufferOutputCallback);
 TJpgDec.drawJpg(ox, oy, data, len);
 TJpgDec.setCallback(tftOutputCallback);
 jpegBufferTarget = nullptr;
 TJpgDec.setJpgScale(1);
 return true;
}
#define WP_LOCK_FILE "/wall_lock.raw"
#define WP_MENU_FILE "/wall_menu.raw"
static bool wpLoadRaw(const char *path, uint16_t *dst) {
 size_t need = (size_t)gfx->width() * gfx->height() * sizeof(uint16_t);
 if (!lfsBegin()) return false;
 if ((size_t)lfsFileSize(path) != need) return false;
 return lfsReadFileInto(path, (uint8_t *)dst, need);
}
bool ensureMenuWallpaperBuf() {
 if (menuWallpaperBufAttempted) return menuWallpaperBufReady;
 menuWallpaperBufAttempted = true;
 menuWpCustom = false;
 if (!menuWallpaperBuf) menuWallpaperBuf = (uint16_t *)allocBuffer((size_t)gfx->width() * gfx->height() * sizeof(uint16_t));
 if (!menuWallpaperBuf) return false;
 if (wpLoadRaw(WP_MENU_FILE, menuWallpaperBuf)) { menuWallpaperBufReady = true; menuWpCustom = true; return true; }
 menuWallpaperBufReady = decodeJpegToBuffer(WALLPAPER_HOME_JPG, WALLPAPER_HOME_JPG_LEN, menuWallpaperBuf);
 return menuWallpaperBufReady;
}
bool menuWpWanted() {
 return false;   // luon nen den
 if (cfgLightTheme) return true;
 if (!ensureMenuWallpaperBuf()) return false;
 return menuWpCustom;
}
bool ensureLockWallpaperBuf() {
 if (lockWallpaperBufAttempted) return lockWallpaperBufReady;
 lockWallpaperBufAttempted = true;
 if (!lockWallpaperBuf) lockWallpaperBuf = (uint16_t *)allocBuffer((size_t)gfx->width() * gfx->height() * sizeof(uint16_t));
 if (!lockWallpaperBuf) return false;
 if (wpLoadRaw(WP_LOCK_FILE, lockWallpaperBuf)) { lockWallpaperBufReady = true; return true; }
 lockWallpaperBufReady = decodeJpegToBuffer(WALLPAPER_LOCK_JPG, WALLPAPER_LOCK_JPG_LEN, lockWallpaperBuf);
 return lockWallpaperBufReady;
}
void blitWallpaperRows(uint16_t *buf, int cx, int srcY, int dstY, int cw, int count) {
 int W = gfx->width();
 gfx->startWrite();
 for (int row = 0; row < count; row++) {
 gfx->draw16bitRGBBitmap(cx, dstY + row, buf + (size_t)(srcY + row) * W + cx, cw, 1);
 }
 gfx->endWrite();
}
void blitWallpaperRect(uint16_t *buf, int cx, int cy, int cw, int ch) {
 blitWallpaperRows(buf, cx, cy, cy, cw, ch);
}
enum { PHOTO_OK = 0, PHOTO_ERR_FORMAT = 1, PHOTO_ERR_DECODE = 2, PHOTO_ERR_NOLIB = 3 };
uint16_t *gLastFrame = nullptr;
int gLastFrameW = 0, gLastFrameH = 0;
static void lastFrameAlloc(int w, int h) {
 if (gLastFrame) { free(gLastFrame); gLastFrame = nullptr; }
 gLastFrame = (uint16_t *)ps_malloc((size_t)w * h * sizeof(uint16_t));
 if (gLastFrame) { memset(gLastFrame, 0, (size_t)w * h * sizeof(uint16_t)); gLastFrameW = w; gLastFrameH = h; }
}
static void lastFrameFree() { if (gLastFrame) { free(gLastFrame); gLastFrame = nullptr; } }
static void lastFrameStore(int x, int y, int w, int h, const uint16_t *bm) {
 if (!gLastFrame) return;
 for (int j = 0; j < h; j++) {
 int yy = y + j;
 if (yy < 0 || yy >= gLastFrameH) continue;
 int x0 = x < 0 ? -x : 0;
 int x1 = (x + w > gLastFrameW) ? (gLastFrameW - x) : w;
 if (x1 <= x0) continue;
 memcpy(gLastFrame + (size_t)yy * gLastFrameW + x + x0, bm + (size_t)j * w + x0, (size_t)(x1 - x0) * sizeof(uint16_t));
 }
}
static uint16_t phXMap[512];
static uint16_t phYMap[512];
static uint16_t phRow[512];
static int phDw = 0, phDh = 0, phOx = 0, phOy = 0, phNextDy = 0;
static void photoFitDims(int srcW, int srcH, int &dw, int &dh) {
 int W = gfx->width(), H = gfx->height();
 if (srcW <= W && srcH <= H) { dw = srcW; dh = srcH; return; }
 if ((int64_t)srcW * H >= (int64_t)srcH * W) { dw = W; dh = (int)((int64_t)srcH * W / srcW); }
 else { dh = H; dw = (int)((int64_t)srcW * H / srcH); }
 if (dw < 1) dw = 1;
 if (dh < 1) dh = 1;
}
void photoSetupFit(int srcW, int srcH) {
 photoFitDims(srcW, srcH, phDw, phDh);
 if (phDw > 512) phDw = 512;
 if (phDh > 512) phDh = 512;
 phOx = (gfx->width() - phDw) / 2;
 phOy = (gfx->height() - phDh) / 2;
 for (int i = 0; i < phDw; i++) phXMap[i] = (uint16_t)(((uint64_t)(2 * i + 1) * srcW) / (2 * phDw));
 for (int i = 0; i < phDh; i++) phYMap[i] = (uint16_t)(((uint64_t)(2 * i + 1) * srcH) / (2 * phDh));
 phNextDy = 0;
}
static int phLower(const uint16_t *m, int n, int v) {
 int lo = 0, hi = n;
 while (lo < hi) { int mid = (lo + hi) >> 1; if (m[mid] < v) lo = mid + 1; else hi = mid; }
 return lo;
}
static inline void phEmitRow(int dy, const uint16_t *srcRow) {
 for (int dx = 0; dx < phDw; dx++) phRow[dx] = srcRow[phXMap[dx]];
 lastFrameStore(phOx, phOy + dy, phDw, 1, phRow);
 gfx->draw16bitRGBBitmap(phOx, phOy + dy, phRow, phDw, 1);
}
bool photoFitJpegCallback(int16_t x, int16_t y, uint16_t w, uint16_t h, uint16_t *bitmap) {
 static uint16_t blk[32 * 32];
 if (w > 32 || h > 32) return true;
 int dx0 = phLower(phXMap, phDw, x), dx1 = phLower(phXMap, phDw, x + w);
 int dy0 = phLower(phYMap, phDh, y), dy1 = phLower(phYMap, phDh, y + h);
 int cw = dx1 - dx0, ch = dy1 - dy0;
 if (cw <= 0 || ch <= 0) return true;
 for (int j = 0; j < ch; j++) {
  const uint16_t *srow = bitmap + (size_t)(phYMap[dy0 + j] - y) * w;
  uint16_t *d = blk + (size_t)j * cw;
  for (int i = 0; i < cw; i++) d[i] = srow[phXMap[dx0 + i] - x];
 }
 lastFrameStore(phOx + dx0, phOy + dy0, cw, ch, blk);
 gfx->draw16bitRGBBitmap(phOx + dx0, phOy + dy0, blk, cw, ch);
 return true;
}
int photoDrawJpeg(const uint8_t *buf, uint32_t len) {
 uint16_t jw = 0, jh = 0;
 if (TJpgDec.getJpgSize(&jw, &jh, buf, len) != JDR_OK || jw == 0 || jh == 0) return PHOTO_ERR_DECODE;
 int fw, fh;
 photoFitDims(jw, jh, fw, fh);
 uint8_t scale = 1;
 while (scale < 8 && (jw / (scale * 2)) >= fw && (jh / (scale * 2)) >= fh) scale *= 2;
 TJpgDec.setJpgScale(scale);
 int dispW = jw / scale, dispH = jh / scale;
 JRESULT r;
 if (dispW <= gfx->width() && dispH <= gfx->height()) {
  int16_t ox = (gfx->width() - dispW) / 2, oy = (gfx->height() - dispH) / 2;
  r = TJpgDec.drawJpg(ox, oy, buf, len);
 } else {
  photoSetupFit(dispW, dispH);
  TJpgDec.setCallback(photoFitJpegCallback);
  r = TJpgDec.drawJpg(0, 0, buf, len);
  TJpgDec.setCallback(tftOutputCallback);
 }
 TJpgDec.setJpgScale(1);
 return r == JDR_OK ? PHOTO_OK : PHOTO_ERR_DECODE;
}
#ifdef HAVE_PNGDEC
static PNG *photoPng = nullptr;
static void photoPngDraw(PNGDRAW *pDraw) {
 static uint16_t line[1024];
 if (pDraw->iWidth > 1024) return;
 int y = pDraw->y;
 while (phNextDy < phDh && phYMap[phNextDy] < y) phNextDy++;
 if (phNextDy >= phDh || phYMap[phNextDy] != y) return;
 photoPng->getLineAsRGB565(pDraw, line, PNG_RGB565_LITTLE_ENDIAN, 0x00000000);
 while (phNextDy < phDh && phYMap[phNextDy] == y) { phEmitRow(phNextDy, line); phNextDy++; }
}
#endif
int photoDrawPng(const uint8_t *buf, uint32_t len) {
#ifdef HAVE_PNGDEC
 photoPng = new (std::nothrow) PNG();
 if (!photoPng) return PHOTO_ERR_DECODE;
 int rc = photoPng->openRAM((uint8_t *)buf, (int)len, photoPngDraw);
 if (rc != PNG_SUCCESS || photoPng->getWidth() > 1024 || photoPng->getHeight() > 65535) { delete photoPng; photoPng = nullptr; return PHOTO_ERR_DECODE; }
 photoSetupFit(photoPng->getWidth(), photoPng->getHeight());
 rc = photoPng->decode(nullptr, 0);
 photoPng->close();
 delete photoPng; photoPng = nullptr;
 return rc == PNG_SUCCESS ? PHOTO_OK : PHOTO_ERR_DECODE;
#else
 return PHOTO_ERR_NOLIB;
#endif
}
int photoDrawBmp(const uint8_t *b, uint32_t len) {
 if (len < 54) return PHOTO_ERR_DECODE;
 auto rd32 = [&](int o) { return (uint32_t)b[o] | ((uint32_t)b[o+1] << 8) | ((uint32_t)b[o+2] << 16) | ((uint32_t)b[o+3] << 24); };
 uint32_t dataOff = rd32(10);
 int32_t w = (int32_t)rd32(18), h = (int32_t)rd32(22);
 uint16_t bpp = b[28] | (b[29] << 8);
 uint32_t comp = rd32(30);
 bool topDown = h < 0; if (h < 0) h = -h;
 if (w <= 0 || h <= 0 || w > 65535 || h > 65535 || (bpp != 24 && bpp != 32) || (comp != 0 && comp != 3)) return PHOTO_ERR_DECODE;
 uint32_t bytesPP = bpp / 8;
 uint32_t stride = (w * bytesPP + 3) & ~3u;
 if ((uint64_t)dataOff + (uint64_t)stride * h > len) return PHOTO_ERR_DECODE;
 photoSetupFit(w, h);
 for (int dy = 0; dy < phDh; dy++) {
  int y = phYMap[dy];
  const uint8_t *row = b + dataOff + (size_t)(topDown ? y : (h - 1 - y)) * stride;
  for (int dx = 0; dx < phDw; dx++) {
   const uint8_t *px = row + (size_t)phXMap[dx] * bytesPP;
   phRow[dx] = ((px[2] & 0xF8) << 8) | ((px[1] & 0xFC) << 3) | (px[0] >> 3);
  }
  lastFrameStore(phOx, phOy + dy, phDw, 1, phRow);
  gfx->draw16bitRGBBitmap(phOx, phOy + dy, phRow, phDw, 1);
 }
 return PHOTO_OK;
}
static uint16_t *fzBuf = nullptr;
static int fzW = 0, fzH = 0;
#define FZ_MAX_BYTES 3145728UL
static bool fzCb(int16_t x, int16_t y, uint16_t w, uint16_t h, uint16_t *bm) {
 if (!fzBuf) return false;
 for (int r = 0; r < h; r++) {
  int yy = y + r;
  if (yy < 0 || yy >= fzH) continue;
  int x0 = x < 0 ? -x : 0;
  int x1 = (x + w > fzW) ? (fzW - x) : w;
  if (x1 <= x0) continue;
  memcpy(fzBuf + (size_t)yy * fzW + x + x0, bm + (size_t)r * w + x0, (size_t)(x1 - x0) * sizeof(uint16_t));
 }
 return true;
}
static void fzFree() { if (fzBuf) { free(fzBuf); fzBuf = nullptr; } fzW = fzH = 0; }
static void fzClamp(float &cx, float &cy, float k) {
 float W = (float)gfx->width(), H = (float)gfx->height();
 float hw = W / (2 * k), hh = H / (2 * k);
 if (2 * hw >= fzW) cx = fzW / 2.0f; else { if (cx < hw) cx = hw; if (cx > fzW - hw) cx = fzW - hw; }
 if (2 * hh >= fzH) cy = fzH / 2.0f; else { if (cy < hh) cy = hh; if (cy > fzH - hh) cy = fzH - hh; }
}
static void fzRender(uint16_t *frame, float cx, float cy, float k) {
 int W = gfx->width(), H = gfx->height();
 float inv = 1.0f / k;
 int n = (k >= 1.0f) ? 1 : (int)ceilf(inv);
 if (n > 4) n = 4;
 static float colX[512];
 if (W > 512) return;
 for (int sx = 0; sx < W; sx++) colX[sx] = cx + (sx - W / 2.0f) * inv;
 float sub = inv / n;
 for (int sy = 0; sy < H; sy++) {
  float by = cy + (sy - H / 2.0f) * inv;
  uint16_t *row = frame + (size_t)sy * W;
  for (int sx = 0; sx < W; sx++) {
   float bx = colX[sx];
   if (bx < 0 || by < 0 || bx >= fzW || by >= fzH) { row[sx] = 0; continue; }
   if (n == 1) { row[sx] = fzBuf[(size_t)(int)by * fzW + (int)bx]; continue; }
   uint32_t r = 0, g = 0, b = 0, c = 0;
   for (int j = 0; j < n; j++) {
    int iy = (int)(by - inv / 2 + (j + 0.5f) * sub);
    if (iy < 0) iy = 0; if (iy >= fzH) iy = fzH - 1;
    for (int i = 0; i < n; i++) {
     int ix = (int)(bx - inv / 2 + (i + 0.5f) * sub);
     if (ix < 0) ix = 0; if (ix >= fzW) ix = fzW - 1;
     uint16_t p = fzBuf[(size_t)iy * fzW + ix];
     r += (p >> 11) & 31; g += (p >> 5) & 63; b += p & 31; c++;
    }
   }
   row[sx] = (uint16_t)(((r / c) << 11) | ((g / c) << 5) | (b / c));
  }
 }
}
static int gFzJw = 0, gFzJh = 0;
static int fzDecodeJpeg(const uint8_t *buf, uint32_t got) {
 uint16_t jw = 0, jh = 0;
 fzFree();
 if (TJpgDec.getJpgSize(&jw, &jh, buf, got) != JDR_OK || jw == 0 || jh == 0) return -1;
 gFzJw = jw; gFzJh = jh;
 int sc = 1;
 while (sc < 8 && (size_t)((jw + sc - 1) / sc) * ((jh + sc - 1) / sc) * 2 > FZ_MAX_BYTES) sc *= 2;
 fzW = (jw + sc - 1) / sc; fzH = (jh + sc - 1) / sc;
 fzBuf = (uint16_t *)allocBuffer((size_t)fzW * fzH * sizeof(uint16_t));
 if (!fzBuf) { fzW = fzH = 0; return -1; }
 memset(fzBuf, 0, (size_t)fzW * fzH * sizeof(uint16_t));
 TJpgDec.setCallback(fzCb);
 TJpgDec.setJpgScale(sc);
 JRESULT jr = TJpgDec.drawJpg(0, 0, buf, got);
 TJpgDec.setJpgScale(1);
 TJpgDec.setCallback(tftOutputCallback);
 if (jr != JDR_OK) { fzFree(); return -1; }
 return 0;
}
static bool fzRotate(int r) {
 r &= 3;
 if (r == 0 || !fzBuf) return true;
 int w = fzW, h = fzH;
 uint16_t *nb = (uint16_t *)allocBuffer((size_t)w * h * sizeof(uint16_t));
 if (!nb) return false;
 if (r == 2) {
  for (int y = 0; y < h; y++) for (int x = 0; x < w; x++) nb[(size_t)y * w + x] = fzBuf[(size_t)(h - 1 - y) * w + (w - 1 - x)];
 } else {
  for (int y = 0; y < w; y++) {
   for (int x = 0; x < h; x++) {
    nb[(size_t)y * h + x] = (r == 1) ? fzBuf[(size_t)(h - 1 - x) * w + y] : fzBuf[(size_t)x * w + (w - 1 - y)];
   }
  }
  fzW = h; fzH = w;
 }
 free(fzBuf); fzBuf = nb;
 return true;
}
static bool gPhotoZoomWant = false, gPhotoZoomOk = false;
void showPhoto(int idx) {
 uint8_t *buf = nullptr;
 uint32_t fsize = 0;
 if (photoIsInternal[idx]) {
 String path = String(INTERNAL_PHOTO_DIR) + "/" + photoList[idx];
 fsize = lfsFileSize(path.c_str());
 if (fsize == 0) { showMessage(tr("Cannot open photo", "Không mở được ảnh")); return; }
 buf = allocBuffer(fsize);
 if (!buf) { showMessage(tr("Out of memory", "Hết bộ nhớ")); return; }
 if (!lfsReadFileInto(path.c_str(), buf, fsize)) {
 free(buf); showMessage(tr("Cannot open photo", "Không mở được ảnh")); return;
 }
 } else {
 String path = String(PHOTO_DIR) + "/" + photoList[idx];
 FsFile f = sd.open(path.c_str(), O_READ);
 if (!f) { showMessage(tr("Cannot open photo", "Không mở được ảnh")); return; }
 fsize = f.fileSize();
 buf = allocBuffer(fsize);
 if (!buf) { f.close(); showMessage(tr("Out of memory", "Hết bộ nhớ")); return; }
 int rd = f.read(buf, fsize);
 f.close();
 if (rd < 0 || (uint32_t)rd != fsize) { free(buf); showMessage(tr("Cannot open photo", "Không mở được ảnh")); return; }
 }
 bool isJpeg = fsize > 3 && buf[0] == 0xFF && buf[1] == 0xD8;
 bool isPng = fsize > 8 && buf[0] == 0x89 && buf[1] == 'P' && buf[2] == 'N' && buf[3] == 'G';
 bool isBmp = fsize > 2 && buf[0] == 'B' && buf[1] == 'M';
 int status = PHOTO_ERR_FORMAT;
 gPhotoZoomOk = false;
 {
 UiCanvasGuard _uiGuard;
 gfx->fillScreen(COLOR_BLACK);
 if (isJpeg) { if (gPhotoZoomWant && fzDecodeJpeg(buf, fsize) == 0) { uint8_t rr = phRotGet(idx); if (rr) fzRotate(rr); gPhotoZoomOk = true; status = PHOTO_OK; } else status = photoDrawJpeg(buf, fsize); } else if (isPng) { status = photoDrawPng(buf, fsize); } else if (isBmp) { status = photoDrawBmp(buf, fsize); }
 }
 free(buf);
 switch (status) {
 case PHOTO_OK: break;
 case PHOTO_ERR_NOLIB:
 showMessage(tr("PNG needs library PNGdec", "PNG cần thư viện PNGdec"), tr("Or convert to .jpg", "Hoặc chuyển sang .jpg"));
 break;
 case PHOTO_ERR_DECODE:
 showMessage(tr("Cannot decode photo", "Không giải mã được ảnh"), tr("Progressive/damaged file - re-save as .jpg", "Ảnh progressive/hỏng - lưu lại dạng .jpg"));
 break;
 default:
 showMessage(tr("Format not supported", "Định dạng chưa hỗ trợ"), tr("Use jpg / png / bmp", "Dùng jpg / png / bmp"));
 break;
 }
}
void copyPhotoToInternal(int idx) {
 if (photoIsInternal[idx]) {
 showMessage(tr("Already on device", "Ảnh đã có trong máy"));
 return;
 }
 if (photoCount >= MAX_PHOTOS) {
 showMessage(tr("Photo list is full", "Danh sách ảnh đã đầy"));
 return;
 }
 String srcPath = String(PHOTO_DIR) + "/" + photoList[idx];
 FsFile src = sd.open(srcPath.c_str(), O_READ);
 if (!src) { showMessage(tr("Cannot open photo", "Không mở được ảnh")); return; }
 uint32_t fsize = src.fileSize();
 if (!lfsBegin()) {
 src.close();
 showMessage(tr("No LittleFS partition", "Không có phân vùng LittleFS"),
 tr("Use a partition scheme with SPIFFS", "Chọn Partition Scheme có SPIFFS"));
 return;
 }
 if (lfsFreeBytes() < (uint64_t)(fsize + 8192)) {
 src.close();
 char l2[40];
 snprintf(l2, sizeof(l2), tr("Free %lu KB, need %lu KB", "Trống %lu KB, cần %lu KB"),
 (unsigned long)(lfsFreeBytes() / 1024), (unsigned long)((fsize + 8192) / 1024));
 showMessage(tr("Not enough space on device", "Không đủ bộ nhớ trong máy"), l2);
 return;
 }
 String dstPath = String(INTERNAL_PHOTO_DIR) + "/" + photoShortName(photoList[idx]);
 if (lfsFileSize(dstPath.c_str()) > 0) {
 src.close();
 showMessage(tr("Already on device", "Ảnh đã có trong máy"));
 return;
 }
 lfsEnsureDir(INTERNAL_PHOTO_DIR);
 void* dst = lfsOpenWrite(dstPath.c_str());
 if (!dst) {
 src.close();
 showMessage(tr("Cannot save photo", "Không lưu được ảnh"));
 return;
 }
 const size_t BIG = 32 * 1024;
 uint8_t small[4096];
 uint8_t *big = (fsize > sizeof(small)) ? allocBuffer(BIG) : nullptr;
 uint8_t *buf = big ? big : small;
 size_t bufSize = big ? BIG : sizeof(small);
 bool ok = true;
 uint32_t remaining = fsize;
 int lastPct = -1;
 while (remaining > 0) {
 size_t chunk = remaining < bufSize ? remaining : bufSize;
 size_t got = src.read(buf, chunk);
 if (got == 0 || !lfsWriteChunk(dst, buf, got)) { ok = false; break; }
 remaining -= got;
 int pct = (int)(((uint64_t)(fsize - remaining) * 100) / fsize);
 if (pct / 10 != lastPct / 10) {
 lastPct = pct;
 char l1[32];
 snprintf(l1, sizeof(l1), "%s %d%%", tr("Saving...", "Đang lưu..."), pct);
 gfx->fillScreen(COLOR_BLACK);
 gfxSetTextColor(COLOR_WHITE, COLOR_BLACK);
 gfxDrawAligned(l1, gfx->width() / 2, gfx->height() / 2, DATUM_MC);
 }
 esp_task_wdt_reset();
 }
 if (big) free(big);
 src.close();
 lfsCloseWrite(dst);
 if (!ok) {
 lfsRemove(dstPath.c_str());
 showMessage(tr("Copy failed", "Sao chép thất bại"));
 return;
 }
 scanInternalPhotos();
 showMessage(tr("Saved to device", "Đã lưu vào máy"));
}
static bool confirmDeletePhoto(const String &name) {
 UiCanvasGuard* _cg = new UiCanvasGuard();
 gfx->fillScreen(COLOR_BLACK);
 gfxSetTextColor(COLOR_YELLOW, COLOR_BLACK);
 gfxDrawAligned(tr("Delete this photo?", "Xoá ảnh này?"), gfx->width() / 2, gfx->height() / 2 - 24, DATUM_MC);
 gfxSetTextColor(COLOR_WHITE, COLOR_BLACK);
 gfxDrawAligned(photoFitName(name, gfx->width() - 16), gfx->width() / 2, gfx->height() / 2, DATUM_MC);
 gfxDrawAligned(tr("Tap screen / Pin14 to confirm", "Chạm màn hình / Pin14 để xoá"), gfx->width() / 2, gfx->height() / 2 + 24, DATUM_MC);
 delete _cg;
 evt_boot_single = evt_boot_double = evt_boot_long = false;
 evt_pin14_single = evt_pin14_double = evt_pin14_long = false;
 delay(300);
 int16_t tx, ty;
 touchTapScreen(tx, ty);
 unsigned long start = millis();
 while (millis() - start < 4000) {
 handleButtons(DOUBLE_WINDOW_MS);
 if (evt_pin14_single || evt_pin14_double || evt_pin14_long) return true;
 if (evt_boot_single || evt_boot_double || evt_boot_long) return false;
 if (touchTapScreen(tx, ty)) return true;
 delay(10);
 }
 return false;
}
void deletePhotoFromInternal(int idx) {
 if (idx < 0 || idx >= photoCount || !photoIsInternal[idx]) return;
 String name = photoList[idx];
 if (!confirmDeletePhoto(name)) return;
 String path = String(INTERNAL_PHOTO_DIR) + "/" + name;
 bool removed = false;
 if (lfsBegin()) {
 lfsRemove(path.c_str());
 removed = (lfsFileSize(path.c_str()) == 0);
 }
 if (!removed) {
 showMessage(tr("Cannot delete photo", "Không xoá được ảnh"));
 return;
 }
 scanInternalPhotos();
 if (photoIndex >= photoCount) photoIndex = photoCount - 1;
 if (photoIndex < 0) photoIndex = 0;
 if (photoTop > photoIndex) photoTop = photoIndex;
 showMessage(tr("Photo deleted", "Đã xoá ảnh"));
}
void drawLastFrameFn() {
 if (gLastFrame) { gfx->draw16bitRGBBitmap(0, 0, gLastFrame, gLastFrameW, gLastFrameH); } else { gfx->fillScreen(COLOR_BLACK); }
}

static void phWaitRelease() {
 int16_t a, b; unsigned long w = millis();
 while (touchReadDebounced(a, b) && millis() - w < 1500) delay(10);
}
static int phSheet(const char *title, const char *const *items, int n) {
 phWaitRelease();
 { int16_t a0, b0; unsigned long tf = millis(); while (millis() - tf < 150) { touchTapScreen(a0, b0); esp_task_wdt_reset(); delay(5); } }
 evt_boot_single = evt_boot_double = evt_boot_long = false;
 evt_pin14_single = evt_pin14_double = evt_pin14_long = false;
 const int W = gfx->width(), H = gfx->height();
 int rowH = min(30, (H - 24) / (n + 1));
 int y0 = H - (n + 1) * rowH - 4;
 int sel = 0;
 bool dirty = true;
 while (true) {
  if (dirty) {
   dirty = false;
   UiCanvasGuard _sg;
   gfx->fillRect(0, y0, W, H - y0, 0x2104);
   gfxSetTextColor(COLOR_WHITE, 0x2104);
   gfxDrawAligned(title, W / 2, y0 + rowH / 2, DATUM_MC);
   for (int i = 0; i < n; i++) {
    int ry = y0 + (i + 1) * rowH;
    uint16_t bg = (i == sel) ? colorAccent : 0x2104;
    gfx->fillRect(4, ry, W - 8, rowH - 2, bg);
    gfxSetTextColor((i == sel) ? (uint16_t)COLOR_BLACK : (uint16_t)COLOR_WHITE, bg);
    gfxDrawAligned(items[i], 12, ry + rowH / 2 - 1, DATUM_ML);
   }
  }
  handleButtons(DOUBLE_WINDOW_MS);
  if (evt_pin14_single) { evt_pin14_single = false; sel = (sel + 1) % n; dirty = true; }
  if (evt_boot_single) { evt_boot_single = false; sel = (sel - 1 + n) % n; dirty = true; }
  if (evt_pin14_double) { evt_pin14_double = false; return sel; }
  if (evt_boot_double) { evt_boot_double = false; return -1; }
  int16_t tx, ty;
  if (touchTapScreen(tx, ty)) {
   if (ty < y0) return -1;
   int i = (ty - y0 - rowH) / rowH;
   if (ty >= y0 + rowH && i >= 0 && i < n) return i;
  }
  esp_task_wdt_reset();
  delay(15);
 }
}
static void phShowInfo(int idx, int jw, int jh) {
 const int W = gfx->width();
 uint32_t fs = 0;
 if (photoIsInternal[idx]) fs = lfsFileSize((String(INTERNAL_PHOTO_DIR) + "/" + photoList[idx]).c_str());
 else { FsFile f = sd.open((String(PHOTO_DIR) + "/" + photoList[idx]).c_str(), O_READ); if (f) { fs = f.fileSize(); f.close(); } }
 UiCanvasGuard* _ig = new UiCanvasGuard();
 gfx->fillScreen(COLOR_BLACK);
 gfxSetTextColor(COLOR_WHITE, COLOR_BLACK);
 gfxDrawAligned(photoFitName(photoList[idx], W - 16), 8, 10, DATUM_TL);
 char l[48];
 snprintf(l, sizeof(l), "%s: %lu KB", tr("Size", "Dung lượng"), (unsigned long)((fs + 512) / 1024));
 gfxDrawAligned(l, 8, 34, DATUM_TL);
 if (jw > 0 && jh > 0) snprintf(l, sizeof(l), "%s: %d x %d", tr("Resolution", "Độ phân giải"), jw, jh);
 else snprintf(l, sizeof(l), "%s: ?", tr("Resolution", "Độ phân giải"));
 gfxDrawAligned(l, 8, 54, DATUM_TL);
 snprintf(l, sizeof(l), "%s: %s", tr("Location", "Vị trí"), photoIsInternal[idx] ? tr("Device", "Trong máy") : "SD /Photos");
 gfxDrawAligned(l, 8, 74, DATUM_TL);
 snprintf(l, sizeof(l), "%d / %d", idx + 1, photoCount);
 gfxDrawAligned(l, 8, 94, DATUM_TL);
 delete _ig;
 phWaitRelease();
 evt_boot_single = evt_boot_double = evt_pin14_single = evt_pin14_double = false;
 unsigned long t = millis();
 int16_t tx, ty;
 while (millis() - t < 30000UL) {
  handleButtons(DOUBLE_WINDOW_MS);
  if (evt_boot_single || evt_boot_double || evt_pin14_single || evt_pin14_double) break;
  if (touchTapScreen(tx, ty)) break;
  esp_task_wdt_reset();
  delay(15);
 }
 evt_boot_single = evt_boot_double = evt_pin14_single = evt_pin14_double = false;
}
static bool phWriteRaw(const char *path, const uint16_t *buf, size_t bytes) {
 void *dst = lfsOpenWrite(path);
 if (!dst) return false;
 bool ok = true;
 const uint8_t *p = (const uint8_t *)buf;
 size_t left = bytes;
 while (left > 0 && ok) { size_t c = left > 4096 ? 4096 : left; ok = lfsWriteChunk(dst, p, c); p += c; left -= c; esp_task_wdt_reset(); }
 lfsCloseWrite(dst);
 if (!ok) lfsRemove(path);
 return ok;
}
static void phSetWallpaper(int target) {
 if (!lfsBegin()) { showMessage(tr("No LittleFS partition", "Không có phân vùng LittleFS")); return; }
 if (target == 3) {
  lfsRemove(WP_LOCK_FILE); lfsRemove(WP_MENU_FILE);
 } else {
  if (!fzBuf || fzW <= 0 || fzH <= 0) { showMessage(tr("Open a JPG photo first", "Hãy mở ảnh JPG trước")); return; }
  const int W = gfx->width(), H = gfx->height();
  size_t bytes = (size_t)W * H * sizeof(uint16_t);
  size_t need = bytes * (target == 2 ? 2 : 1) + 8192;
  if (lfsFreeBytes() < need) { showMessage(tr("Not enough space on device", "Không đủ bộ nhớ trong máy")); return; }
  uint16_t *buf = (uint16_t *)allocBuffer(bytes);
  if (!buf) { showMessage(tr("Out of memory", "Hết bộ nhớ")); return; }
  float k = max((float)W / fzW, (float)H / fzH);
  fzRender(buf, fzW / 2.0f, fzH / 2.0f, k);
  bool ok = true;
  if (target == 0 || target == 2) ok = phWriteRaw(WP_LOCK_FILE, buf, bytes) && ok;
  if (target == 1 || target == 2) ok = phWriteRaw(WP_MENU_FILE, buf, bytes) && ok;
  free(buf);
  if (!ok) { showMessage(tr("Cannot save wallpaper", "Không lưu được hình nền")); return; }
  if ((target == 0 || target == 2) && cfgActivated && !cfgWallpaperLock) { cfgWallpaperLock = true; prefs.putBool("wplock", true); }
 }
 if (target == 0 || target == 2 || target == 3) { lockWallpaperBufAttempted = false; lockWallpaperBufReady = false; ensureLockWallpaperBuf(); }
 if (target == 1 || target == 2 || target == 3) { menuWallpaperBufAttempted = false; menuWallpaperBufReady = false; ensureMenuWallpaperBuf(); }
 showMessage(target == 3 ? tr("Default wallpaper restored", "Đã khôi phục nền mặc định") : tr("Wallpaper set", "Đã đặt hình nền"));
}
static bool phDeleteAny(int idx) {
 if (idx < 0 || idx >= photoCount) return false;
 int before = photoCount;
 if (photoIsInternal[idx]) {
  deletePhotoFromInternal(idx);
  return photoCount < before;
 }
 String name = photoList[idx];
 if (!confirmDeletePhoto(name)) return false;
 String key = phKey(idx);
 bool ok = sd.remove((String(PHOTO_DIR) + "/" + name).c_str());
 if (!ok) { showMessage(tr("Cannot delete photo", "Không xoá được ảnh")); return false; }
 sd.remove((String(PH_THUMB_DIR) + "/" + key + ".t").c_str());
 sd.remove((String(PH_THUMB_DIR) + "/" + key + ".r").c_str());
 scanPhotos();
 if (!hasFullAccess() && photoCount > FREE_MAX_PHOTOS) photoCount = FREE_MAX_PHOTOS;
 if (photoIndex >= photoCount) photoIndex = photoCount - 1;
 if (photoIndex < 0) photoIndex = 0;
 showMessage(tr("Photo deleted", "Đã xoá ảnh"));
 return true;
}
static int phOutsideSheet(int idx) {
 const char *it[3];
 it[0] = tr("Set as wallpaper", "Đặt làm hình nền");
 it[1] = photoIsInternal[idx] ? tr("Already on device", "Đã có trong máy") : tr("Move to device", "Di chuyển vào máy");
 it[2] = tr("Delete", "Xoá ảnh");
 int r = phSheet(tr("Photo options", "Tuỳ chọn ảnh"), it, 3);
 if (r == 0) return 2;
 if (r == 1) return 5;
 if (r == 2) return 4;
 return -1;
}
static int phActionSheet(int idx) {
 const char *it[6];
 it[0] = tr("Rotate right", "Xoay phải");
 it[1] = tr("Info", "Thông tin");
 it[2] = tr("Set as wallpaper", "Đặt làm hình nền");
 it[3] = photoIsInternal[idx] ? tr("Already on device", "Đã có trong máy") : tr("Save to device", "Lưu vào máy");
 it[4] = photoIsInternal[idx] ? tr("Already on device", "Đã có trong máy") : tr("Move to device", "Di chuyển vào máy");
 it[5] = tr("Delete", "Xoá ảnh");
 int r = phSheet(tr("Photo options", "Tuỳ chọn ảnh"), it, 6);
 if (r == 4) return 5;
 if (r == 5) return 4;
 return r;
}
static bool phWallpaperFlow(bool jpgOk) {
 const char *wi[4] = { tr("Lock screen", "Màn hình khoá"), tr("Menu", "Menu"), tr("Both", "Cả hai"), tr("Restore default", "Khôi phục mặc định") };
 int wsel = phSheet(tr("Set wallpaper", "Đặt hình nền"), wi, 4);
 if (wsel < 0) return false;
 if (wsel == 3 || jpgOk) { phSetWallpaper(wsel); return true; }
 showMessage(tr("Wallpaper: JPG only", "Nền: chỉ ảnh JPG"));
 return true;
}
static void phMoveToDevice(int &idx) {
 if (idx < 0 || idx >= photoCount || photoIsInternal[idx]) { showMessage(tr("Already on device", "Ảnh đã có trong máy")); return; }
 String nm = photoList[idx];
 String key = phKey(idx);
 String dst = String(INTERNAL_PHOTO_DIR) + "/" + photoShortName(nm);
 if (lfsBegin() && lfsFileSize(dst.c_str()) > 0) { showMessage(tr("Already on device", "Ảnh đã có trong máy")); return; }
 copyPhotoToInternal(idx);
 if (!(lfsBegin() && lfsFileSize(dst.c_str()) > 0)) return;
 sd.remove((String(PHOTO_DIR) + "/" + nm).c_str());
 sd.remove((String(PH_THUMB_DIR) + "/" + key + ".t").c_str());
 sd.remove((String(PH_THUMB_DIR) + "/" + key + ".r").c_str());
 scanPhotos();
 if (!hasFullAccess() && photoCount > FREE_MAX_PHOTOS) photoCount = FREE_MAX_PHOTOS;
 if (idx >= photoCount) idx = photoCount - 1;
 if (idx < 0) idx = 0;
 showMessage(tr("Moved to device", "Đã di chuyển vào máy"));
}
void runPhotoViewer(int startIndex) {
 int idx = startIndex;
 bool needDraw = true;
 bool swiped = false;
 int W = gfx->width(), H = gfx->height();
 lastFrameAlloc(W, H);
 uint16_t *frame = (uint16_t *)allocBuffer((size_t)W * H * sizeof(uint16_t));
 gPhotoZoomWant = (frame != nullptr);
 bool zoomable = false, zoomed = false, redraw = false, pressed = false, panning = false, sheetFired = false;
 float cx = 0, cy = 0, k = 1, fitK = 1, zoomK = 1, panCx = 0, panCy = 0;
 int16_t x0 = 0, y0 = 0, x1 = 0, y1 = 0, lastTx = -100, lastTy = -100;
 unsigned long t0 = 0, lastTapMs = 0, lastRender = 0;
 while (true) {
  if (needDraw) {
   needDraw = false; zoomed = false; zoomable = false;
   if (gLastFrame) memset(gLastFrame, 0, (size_t)gLastFrameW * gLastFrameH * sizeof(uint16_t));
   showPhoto(idx);
   if (gPhotoZoomOk) {
    zoomable = true;
    fitK = min((float)W / fzW, (float)H / fzH);
    zoomK = max(fitK * 3.0f, 1.0f);
    k = fitK; cx = fzW / 2.0f; cy = fzH / 2.0f;
    redraw = true;
   }
  }
  if (redraw) {
   redraw = false;
   fzClamp(cx, cy, k);
   fzRender(frame, cx, cy, k);
   gfx->draw16bitRGBBitmap(0, 0, frame, W, H);
   lastFrameStore(0, 0, W, H, frame);
   lastRender = millis();
  }
  handleButtons(DOUBLE_WINDOW_MS);
  if (evt_boot_long) {
   evt_boot_long = false;
   if (confirmPowerOff()) powerOff(); else needDraw = true;
  }
  if (evt_boot_double) { evt_boot_double = false; break; }
  if (evt_pin14_single) { evt_pin14_single = false; idx = (idx + 1) % photoCount; needDraw = true; }
  if (evt_boot_single) { evt_boot_single = false; idx = (idx - 1 + photoCount) % photoCount; needDraw = true; }
  if (evt_pin14_double) {
   evt_pin14_double = false;
   copyPhotoToInternal(idx);
   needDraw = true;
  }
  if (evt_pin14_long) { evt_pin14_long = false; }
  if (touchSwipeUpExit(52, true)) { swiped = true; break; }
  int16_t nx, ny, sx, sy;
  bool down = touchReadDebounced(nx, ny);
  if (down) {
   touchToScreen(nx, ny, sx, sy);
   if (!pressed) { pressed = true; panning = false; x0 = sx; y0 = sy; t0 = millis(); panCx = cx; panCy = cy; }
   x1 = sx; y1 = sy;
   if (!panning && !sheetFired && millis() - t0 > 500 && abs(x1 - x0) < 16 && abs(y1 - y0) < 16 && y0 < H - 16) {
    sheetFired = true;
    bool outside = false;
    if (zoomable && !zoomed) {
     float dw = fzW * fitK, dh = fzH * fitK;
     outside = (x0 < (W - dw) / 2 - 2 || x0 > (W + dw) / 2 + 2 || y0 < (H - dh) / 2 - 2 || y0 > (H + dh) / 2 + 2);
    }
    int act = outside ? phOutsideSheet(idx) : phActionSheet(idx);
    bool refresh = true;
    if (act == 0) {
     if (zoomable && fzRotate(1)) {
      phRotSet(idx, (uint8_t)(phRotGet(idx) + 1));
      fitK = min((float)W / fzW, (float)H / fzH); zoomK = max(fitK * 3.0f, 1.0f);
      zoomed = false; k = fitK; cx = fzW / 2.0f; cy = fzH / 2.0f;
      refresh = false; redraw = true;
     } else showMessage(tr("Rotate: JPG only", "Chỉ xoay được ảnh JPG"));
    } else if (act == 1) {
     phShowInfo(idx, zoomable ? gFzJw : 0, zoomable ? gFzJh : 0);
    } else if (act == 2) {
     phWallpaperFlow(zoomable);
    } else if (act == 5) {
     phMoveToDevice(idx);
     if (photoCount == 0) { break; }
     refresh = false; needDraw = true; redraw = false;
    } else if (act == 3) {
     copyPhotoToInternal(idx);
    } else if (act == 4) {
     if (phDeleteAny(idx)) {
      if (photoCount == 0) { break; }
      if (idx >= photoCount) idx = photoCount - 1;
      refresh = false; needDraw = true; redraw = false;
     }
    }
    if (refresh) { if (zoomable) redraw = true; else needDraw = true; }
    continue;
   }
   if (zoomed && zoomable && y0 < H - GESTURE_ARM_ZONE_H && (abs(x1 - x0) > 6 || abs(y1 - y0) > 6)) {
    panning = true;
    if (millis() - lastRender > 25) { cx = panCx - (x1 - x0) / k; cy = panCy - (y1 - y0) / k; redraw = true; }
   }
  } else if (pressed) {
   pressed = false;
   if (sheetFired) { sheetFired = false; continue; }
   int dx = x1 - x0, dy = y1 - y0;
   if (panning) { cx = panCx - dx / k; cy = panCy - dy / k; redraw = true; }
   else if (y0 < H - GESTURE_ARM_ZONE_H) {
    if (!zoomed && abs(dx) > 40 && abs(dx) > abs(dy)) {
     idx = (dx < 0) ? (idx + 1) % photoCount : (idx - 1 + photoCount) % photoCount;
     needDraw = true;
    } else if (abs(dx) < 12 && abs(dy) < 12 && millis() - t0 < 500) {
     unsigned long now = millis();
     if (!zoomable) { idx = (idx + 1) % photoCount; needDraw = true; }
     else if (now - lastTapMs < 380 && abs(x0 - lastTx) < 40 && abs(y0 - lastTy) < 40) {
      lastTapMs = 0;
      if (!zoomed) {
       float bx = fzW / 2.0f + (x0 - W / 2.0f) / fitK, by = fzH / 2.0f + (y0 - H / 2.0f) / fitK;
       zoomed = true; k = zoomK; cx = bx; cy = by;
      } else { zoomed = false; k = fitK; cx = fzW / 2.0f; cy = fzH / 2.0f; }
      redraw = true;
     } else { lastTapMs = now; lastTx = x0; lastTy = y0; }
    }
   }
  }
  delay(15);
 }
 gPhotoZoomWant = false;
 fzFree();
 if (frame) free(frame);
 if (swiped && gLastFrame) {
  int rowH = 21, startY = 22;
  int row = photoIndex - photoTop; if (row < 0) row = 0;
  closeScreenWithZoom(0, startY + row * rowH, gfx->width(), rowH, drawLastFrameFn, drawPhotoMenu);
 }
 lastFrameFree();
}
const char* SEARCH_KB_ROW0[] = { "q", "w", "e", "r", "t", "y", "u", "i", "o", "p" };
const char* SEARCH_KB_ROW1[] = { "a", "s", "d", "f", "g", "h", "j", "k", "l" };
const char* SEARCH_KB_ROW2[] = { "z", "x", "c", "v", "b", "n", "m" };
const char* SEARCH_KB_ROW3[] = { " " };
const char** SEARCH_KB_ROWS[] = { SEARCH_KB_ROW0, SEARCH_KB_ROW1, SEARCH_KB_ROW2, SEARCH_KB_ROW3 };
const char* SEARCH_KB2_ROW0[] = { "1", "2", "3", "4", "5", "6", "7", "8", "9", "0" };
const char* SEARCH_KB2_ROW1[] = { "-", "/", ":", ";", "(", ")", "&", "@", "_" };
const char* SEARCH_KB2_ROW2[] = { ".", ",", "?", "!", "'", "\"", "+" };
const char* SEARCH_KB2_ROW3[] = { " " };
const char** SEARCH_KB2_ROWS[] = { SEARCH_KB2_ROW0, SEARCH_KB2_ROW1, SEARCH_KB2_ROW2, SEARCH_KB2_ROW3 };
bool ttSearchPage2 = false;
bool ttSearchShift = false;

static inline bool ykOn() { return true; }
static inline bool ykHdrOn() { return searchMode == SEARCH_YOUTUBE; }
static String ykGoLabel() { return (searchMode == SEARCH_YOUTUBE) ? String(tr("Search", "Tìm")) : String("GO"); }
enum { YK_CHAR, YK_SHIFT, YK_DEL, YK_TOG, YK_SPACE, YK_GO };
#define YK_UNITS 40
#define YK_MARGIN 4
static const YkCell YK1_R0[] = { {YK_CHAR,4,"q"},{YK_CHAR,4,"w"},{YK_CHAR,4,"e"},{YK_CHAR,4,"r"},{YK_CHAR,4,"t"},{YK_CHAR,4,"y"},{YK_CHAR,4,"u"},{YK_CHAR,4,"i"},{YK_CHAR,4,"o"},{YK_CHAR,4,"p"} };
static const YkCell YK1_R1[] = { {YK_CHAR,4,"a"},{YK_CHAR,4,"s"},{YK_CHAR,4,"d"},{YK_CHAR,4,"f"},{YK_CHAR,4,"g"},{YK_CHAR,4,"h"},{YK_CHAR,4,"j"},{YK_CHAR,4,"k"},{YK_CHAR,4,"l"} };
static const YkCell YK1_R2[] = { {YK_SHIFT,6,""},{YK_CHAR,4,"z"},{YK_CHAR,4,"x"},{YK_CHAR,4,"c"},{YK_CHAR,4,"v"},{YK_CHAR,4,"b"},{YK_CHAR,4,"n"},{YK_CHAR,4,"m"},{YK_DEL,6,""} };
static const YkCell YK1_R3[] = { {YK_TOG,9,"123"},{YK_SPACE,22," "},{YK_GO,9,""} };
static const YkCell YK2_R0[] = { {YK_CHAR,4,"1"},{YK_CHAR,4,"2"},{YK_CHAR,4,"3"},{YK_CHAR,4,"4"},{YK_CHAR,4,"5"},{YK_CHAR,4,"6"},{YK_CHAR,4,"7"},{YK_CHAR,4,"8"},{YK_CHAR,4,"9"},{YK_CHAR,4,"0"} };
static const YkCell YK2_R1[] = { {YK_CHAR,4,"-"},{YK_CHAR,4,"/"},{YK_CHAR,4,":"},{YK_CHAR,4,";"},{YK_CHAR,4,"("},{YK_CHAR,4,")"},{YK_CHAR,4,"&"},{YK_CHAR,4,"@"},{YK_CHAR,4,"_"},{YK_CHAR,4,"\""} };
static const YkCell YK2_R2[] = { {YK_CHAR,6,"#"},{YK_CHAR,4,"."},{YK_CHAR,4,","},{YK_CHAR,4,"?"},{YK_CHAR,4,"!"},{YK_CHAR,4,"'"},{YK_CHAR,4,"+"},{YK_CHAR,4,"="},{YK_DEL,6,""} };
static const YkCell YK2_R3[] = { {YK_TOG,9,"abc"},{YK_SPACE,22," "},{YK_GO,9,""} };
static const YkCell *const YK_ROWS[2][4] = { { YK1_R0, YK1_R1, YK1_R2, YK1_R3 }, { YK2_R0, YK2_R1, YK2_R2, YK2_R3 } };
static const uint8_t YK_LENS[2][4] = {
 { sizeof(YK1_R0)/sizeof(YkCell), sizeof(YK1_R1)/sizeof(YkCell), sizeof(YK1_R2)/sizeof(YkCell), sizeof(YK1_R3)/sizeof(YkCell) },
 { sizeof(YK2_R0)/sizeof(YkCell), sizeof(YK2_R1)/sizeof(YkCell), sizeof(YK2_R2)/sizeof(YkCell), sizeof(YK2_R3)/sizeof(YkCell) } };
static bool ykFocusOn = false;
static int ykPrRow = -1, ykPrCol = -1;
static bool ykPrBubble = false;
static unsigned long ykPrUntil = 0;
static inline int ykLen(int row) { return YK_LENS[ttSearchPage2 ? 1 : 0][row]; }
static inline const YkCell &ykCell(int row, int col) { return YK_ROWS[ttSearchPage2 ? 1 : 0][row][col]; }
static inline int ykKindAt(int row, int col) {
 if (row < 0 || row > 3 || col < 0 || col >= ykLen(row)) return -1;
 return ykCell(row, col).kind;
}
static void ykGeom(int row, int col, int &x, int &w) {
 const YkCell *r = YK_ROWS[ttSearchPage2 ? 1 : 0][row];
 int n = ykLen(row), sum = 0;
 for (int i = 0; i < n; i++) sum += r[i].w;
 int a = (YK_UNITS - sum) / 2;
 for (int i = 0; i < col; i++) a += r[i].w;
 int span = gfx->width() - 2 * YK_MARGIN + 3;
 int x0 = YK_MARGIN + a * span / YK_UNITS;
 int x1 = YK_MARGIN + (a + r[col].w) * span / YK_UNITS;
 x = x0; w = x1 - x0;
}
static int ykColAt(int row, int sx) {
 int n = ykLen(row);
 for (int c = 0; c < n; c++) {
  int x, w; ykGeom(row, c, x, w);
  if (sx < x + w) return c;
 }
 return n - 1;
}
static void ykClampCursor() {
 if (ttSearchRow < 0) ttSearchRow = 0;
 if (ttSearchRow > 3) ttSearchRow = 3;
 int n = ykLen(ttSearchRow);
 if (ttSearchCol >= n) ttSearchCol = n - 1;
 if (ttSearchCol < 0) ttSearchCol = 0;
}
inline const char* ttSearchTileStr(int row, int col) { if (ykOn()) return ykCell(row, col).s; return (ttSearchPage2 ? SEARCH_KB2_ROWS : SEARCH_KB_ROWS)[row][col]; }
const int SEARCH_KB_ROW_LENS[] = {
 sizeof(SEARCH_KB_ROW0) / sizeof(SEARCH_KB_ROW0[0]),
 sizeof(SEARCH_KB_ROW1) / sizeof(SEARCH_KB_ROW1[0]),
 sizeof(SEARCH_KB_ROW2) / sizeof(SEARCH_KB_ROW2[0]),
 sizeof(SEARCH_KB_ROW3) / sizeof(SEARCH_KB_ROW3[0]),
};
#define SEARCH_KB_ROW_COUNT 4
#define SEARCH_MAX_LEN 40
char ttSearchQuery[SEARCH_MAX_LEN + 1] = "";
char gSearchQueryCopy[SEARCH_MAX_LEN + 1] = "";
int ttSearchLen = 0;
int ttSearchRow = 0;
int ttSearchCol = 0;
bool ttSearchCursorOn = true;
unsigned long ttSearchCursorBlinkMs = 0;
void ttSearchResetCursorBlink() { ttSearchCursorOn = true; ttSearchCursorBlinkMs = millis(); }
int ttSearchRowLen(int row) {
 if (ykOn()) return ykLen(row);
 int n = SEARCH_KB_ROW_LENS[row];
 if (row == SEARCH_KB_ROW_COUNT - 1) n += 5;
 return n;
}
void drawSearch();
#define MAX_SEARCH_RESULTS 12
TTSearchResult searchResults[MAX_SEARCH_RESULTS];
int searchResultCount = 0;
int searchResultIndex = 0;
int searchResultTop = 0;
static bool gGoogleShowSel = false;
static String gImgUrl[MAX_SEARCH_RESULTS];
static bool gImgFailed[MAX_SEARCH_RESULTS];
static int gDetImgIdx = -1;
static int googleDetailImgLine = -1;
static bool gRowCached[MAX_SEARCH_RESULTS];
static String gRowHost[MAX_SEARCH_RESULTS];
static String gRowHostT[MAX_SEARCH_RESULTS];
static String gRowTitle[MAX_SEARCH_RESULTS];
static String gRowSnip[MAX_SEARCH_RESULTS];
static void googleClearRowCache() { for (int i = 0; i < MAX_SEARCH_RESULTS; i++) gRowCached[i] = false; }
int googleDetailLineTop = 0;
int googleDetailLineCount = 0;
struct { bool active = false; bool dragging = false; int16_t startX = 0, startY = 0; int startTop = 0; int offsetPx = 0; } googleDetailTouch;
#define YTH_MAX 8
#define YTR_MAX 6
#define YTT_MAX 12
#define YT_ROW_H 44
#define YT_TH_W 64
#define YT_TH_H 36
static String gYtHist[YTH_MAX];
static int gYtHistN = 0;
static YtListItem gYtRec[YTR_MAX];
static int gYtRecN = 0;
static YtListItem gYtTrend[YTT_MAX];
static int gYtTrendN = 0;
static volatile uint8_t gYtTrendState = 0;
static volatile bool gYtTrendStale = false;
static unsigned long gYtTrendMs = 0;
static bool gYtStoreLoaded = false;
static bool gYtHomeOn = false;
static bool gMusicHomeOn = false;
static int gYtHomeIdx = 0, gYtHomeTop = 0;
static bool gYtHomeSel = false;
static int gYtHomeLastOff = 0;
static bool gYtTapValid = false;
static uint16_t *gYtTh[MAX_SEARCH_RESULTS];
static uint8_t gYtThState[MAX_SEARCH_RESULTS];
static String gYtThVid[MAX_SEARCH_RESULTS];
static void ytHomeReset() { gYgSel = -1; gYgTop = 0; gYgPos = 0; gYgFilter = 0; gYtHomeIdx = 0; gYtHomeTop = 0; gYtHomeSel = false; gYtHomeLastOff = 0; gYtTapValid = false; }
static String ytIdOfUrlStr(const String &url) {
 int p = url.indexOf("v=");
 if (p < 0 || (int)url.length() < p + 13) return String("");
 return url.substring(p + 2, p + 13);
}
static String ytCleanField(String s) {
 s.replace('\t', ' ');
 s.replace('\n', ' ');
 s.replace('\r', ' ');
 s.trim();
 return s;
}
static String ytCapBytes(String s, int maxBytes) {
 if ((int)s.length() <= maxBytes) return s;
 int n = maxBytes;
 while (n > 0 && (((uint8_t)s[n]) & 0xC0) == 0x80) n--;
 return s.substring(0, n);
}
static void ytStoreLoad() {
 if (gYtStoreLoaded) return;
 gYtStoreLoaded = true;
 gYtHistN = 0;
 gYtRecN = 0;
 String h = prefs.getString("yth", "");
 int p = 0;
 while (p < (int)h.length() && gYtHistN < YTH_MAX) {
  int e = h.indexOf('\n', p);
  if (e < 0) e = (int)h.length();
  if (e > p) gYtHist[gYtHistN++] = h.substring(p, e);
  p = e + 1;
 }
 String r = prefs.getString("ytr", "");
 p = 0;
 while (p < (int)r.length() && gYtRecN < YTR_MAX) {
  int e = r.indexOf('\n', p);
  if (e < 0) e = (int)r.length();
  String line = r.substring(p, e);
  p = e + 1;
  int a = line.indexOf('\t');
  int b = (a < 0) ? -1 : line.indexOf('\t', a + 1);
  int c = (b < 0) ? -1 : line.indexOf('\t', b + 1);
  if (a <= 0 || b < 0 || c < 0) continue;
  YtListItem &it = gYtRec[gYtRecN++];
  it.id = line.substring(0, a);
  it.title = line.substring(a + 1, b);
  it.chan = line.substring(b + 1, c);
  it.dur = line.substring(c + 1);
 }
}
static void ytHistAdd(const char *q) {
 ytStoreLoad();
 String s = ytCapBytes(ytCleanField(String(q)), 80);
 if (s.length() == 0) return;
 int at = -1;
 for (int i = 0; i < gYtHistN; i++) { if (gYtHist[i].equalsIgnoreCase(s)) { at = i; break; } }
 if (at < 0) {
  if (gYtHistN < YTH_MAX) gYtHistN++;
  at = gYtHistN - 1;
 }
 for (int i = at; i > 0; i--) gYtHist[i] = gYtHist[i - 1];
 gYtHist[0] = s;
 String out;
 for (int i = 0; i < gYtHistN; i++) { out += gYtHist[i]; out += '\n'; }
 prefs.putString("yth", out);
}
#define MUSH_MAX 8
static String gMusHist[MUSH_MAX];
static int gMusHistN = 0;
static bool gMusHistLoaded = false;
static void musicHistLoad() {
 if (gMusHistLoaded) return;
 gMusHistLoaded = true;
 gMusHistN = 0;
 String h = prefs.getString("ymh", "");
 int p = 0;
 while (p < (int)h.length() && gMusHistN < MUSH_MAX) {
  int e = h.indexOf('\n', p);
  if (e < 0) e = (int)h.length();
  if (e > p) gMusHist[gMusHistN++] = h.substring(p, e);
  p = e + 1;
 }
}
static void musicHistAdd(const char *q) {
 musicHistLoad();
 String s = ytCapBytes(ytCleanField(String(q)), 80);
 if (s.length() == 0) return;
 int at = -1;
 for (int i = 0; i < gMusHistN; i++) { if (gMusHist[i].equalsIgnoreCase(s)) { at = i; break; } }
 if (at < 0) {
  if (gMusHistN < MUSH_MAX) gMusHistN++;
  at = gMusHistN - 1;
 }
 for (int i = at; i > 0; i--) gMusHist[i] = gMusHist[i - 1];
 gMusHist[0] = s;
 String out;
 for (int i = 0; i < gMusHistN; i++) { out += gMusHist[i]; out += '\n'; }
 prefs.putString("ymh", out);
}
static void ytRecAdd(const String &id, const String &title, const String &chan, const String &dur) {
 if (id.length() != 11) return;
 ytStoreLoad();
 int at = -1;
 for (int i = 0; i < gYtRecN; i++) { if (gYtRec[i].id == id) { at = i; break; } }
 if (at < 0) {
  if (gYtRecN < YTR_MAX) gYtRecN++;
  at = gYtRecN - 1;
 }
 for (int i = at; i > 0; i--) gYtRec[i] = gYtRec[i - 1];
 gYtRec[0].id = id;
 gYtRec[0].title = ytCapBytes(ytCleanField(title), 100);
 gYtRec[0].chan = ytCapBytes(ytCleanField(chan), 40);
 gYtRec[0].dur = ytCleanField(dur);
 String out;
 for (int i = 0; i < gYtRecN; i++) {
  out += gYtRec[i].id; out += '\t';
  out += gYtRec[i].title; out += '\t';
  out += gYtRec[i].chan; out += '\t';
  out += gYtRec[i].dur; out += '\n';
 }
 prefs.putString("ytr", out);
}
static void ytThumbFreeAll() {
 for (int i = 0; i < MAX_SEARCH_RESULTS; i++) {
  if (gYtTh[i]) { free(gYtTh[i]); gYtTh[i] = nullptr; }
  gYtThState[i] = 0;
  gYtThVid[i] = "";
 }
}
static void ytTrendTask(void *param) {
 String body;
 const bool freshReq = gYtTrendStale;
 gYtTrendStale = false;
 int code = ynGet(pickRelayHost(false) + "/yt/trending?n=" + String(YTT_MAX) + "&lang=" + (cfgVietnamese ? "vi" : "en") + (freshReq ? "&fresh=1" : "") + relayTk(), body, 15000, 30000, false, "trend");
 static YtListItem tmp[YTT_MAX];
 int n = 0;
 if (code == 200 && body.length() > 2) {
  DynamicJsonDocument doc((size_t)body.length() + 1024);
  if (doc.capacity() > 0) {
   DeserializationError derr = deserializeJson(doc, body);
   if (!derr) {
    JsonArray arr = doc.as<JsonArray>();
    if (arr.isNull() && doc.is<JsonObject>()) arr = doc["results"].as<JsonArray>();
    if (!arr.isNull()) {
     for (JsonObject item : arr) {
      if (n >= YTT_MAX) break;
      const char *id = item["id"] | "";
      if (!id[0]) continue;
      tmp[n].id = String(id);
      tmp[n].title = String((const char *)(item["title"] | ""));
      tmp[n].chan = String((const char *)(item["channel"] | ""));
      tmp[n].dur = String((const char *)(item["duration"] | ""));
      tmp[n].views = (uint32_t)(item["views"] | 0);
      n++;
     }
    }
   }
  }
 }
 if (n > 0) {
  for (int i = 0; i < n; i++) gYtTrend[i] = tmp[i];
  gYtTrendN = n;
 }
 gYtTrendMs = millis();
 gYtTrendState = (gYtTrendN > 0) ? 2 : 3;
 vTaskDelete(NULL);
}
static void ytClosedTask(void *param) {
 String body;
 ynGet(pickRelayHost(false) + "/yt/closed?lang=" + (cfgVietnamese ? "vi" : "en") + relayTk(), body, 8000, 12000, false, "ytclosed");
 vTaskDelete(NULL);
}
static void ytClosedNotify() {
 gYtTrendStale = true;
 if (!wifiOK || gSearchBusy || gYtTrendState == 1) return;
 startNetTask(ytClosedTask, "ytClosed", 16384);
}
static void ytTrendKick() {
 if (gYtTrendState == 1) return;
 if (!wifiOK || gSearchBusy) return;
 gYtTrendState = 1;
 if (!startNetTask(ytTrendTask, "ytTrend", 16384)) { gYtTrendState = 3; gYtTrendMs = millis(); }
}
struct SearchSession {
 bool used;
 char query[SEARCH_MAX_LEN + 1];
 int len, row, col;
 bool page2, shift;
 TTSearchResult results[MAX_SEARCH_RESULTS];
 int resultCount, resultIndex, resultTop;
 String imgUrl[MAX_SEARCH_RESULTS];
 bool imgFailed[MAX_SEARCH_RESULTS];
 bool googleShowSel;
 int detailLineTop, detailLineCount;
};
static SearchSession *gSearchSess[3] = { nullptr, nullptr, nullptr };
static inline int searchSessIdx(SearchMode m) { return (m == SEARCH_GOOGLE) ? 1 : ((m == SEARCH_MUSIC) ? 2 : 0); }
static inline int searchSessIdxForRow(int row) { return (row == rowGoogle()) ? 1 : ((row == rowMusic()) ? 2 : 0); }
static void searchSessSave(SearchMode m) {
 if (gSearchBusy) return;
 int k = searchSessIdx(m);
 if (!gSearchSess[k]) {
 void *mem = heap_caps_calloc(1, sizeof(SearchSession), MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT);
 if (!mem) mem = calloc(1, sizeof(SearchSession));
 if (!mem) return;
 gSearchSess[k] = new (mem) SearchSession();
 }
 SearchSession *s = gSearchSess[k];
 memcpy(s->query, ttSearchQuery, sizeof(s->query));
 s->len = ttSearchLen; s->row = ttSearchRow; s->col = ttSearchCol;
 s->page2 = ttSearchPage2; s->shift = ttSearchShift;
 for (int i = 0; i < MAX_SEARCH_RESULTS; i++) {
 s->results[i] = searchResults[i];
 s->imgUrl[i] = gImgUrl[i];
 s->imgFailed[i] = gImgFailed[i];
 }
 s->resultCount = searchResultCount; s->resultIndex = searchResultIndex; s->resultTop = searchResultTop;
 s->googleShowSel = gGoogleShowSel;
 s->detailLineTop = googleDetailLineTop; s->detailLineCount = googleDetailLineCount;
 s->used = true;
}
